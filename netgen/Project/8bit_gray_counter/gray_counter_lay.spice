* SPICE3 file created from asyn_rst_8_gray_counter.ext - technology: sky130A

.option scale=5000u

*.subckt asyn_rst_8_gray_counter RSTB EN CLK Q0 Q1 Q2 Q3 Q4 Q5 Q6 Q7 Vdd gnd
Xasyn_gr_counter_cell_0/sky130_fd_sc_lp__xor2_1_0 asyn_gr_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_gr_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd Q0 sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_0/sky130_fd_sc_lp__and2_1_0 asyn_gr_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B
+ EN gnd gnd Vdd Vdd asyn_gr_counter_cell_1/sky130_fd_sc_lp__and2_1_0/B sky130_fd_sc_lp__and2_1
Xasyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 EN asyn_gr_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B
+ gnd gnd Vdd Vdd asyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 EN asyn_gr_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B
+ gnd gnd Vdd Vdd asyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 EN asyn_gr_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B
+ gnd gnd Vdd Vdd asyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 EN asyn_gr_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B
+ gnd gnd Vdd Vdd asyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_gr_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_1/sky130_fd_sc_lp__xor2_1_0 asyn_gr_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_gr_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd Q1 sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_1/sky130_fd_sc_lp__and2_1_0 asyn_gr_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_gr_counter_cell_1/sky130_fd_sc_lp__and2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_2/sky130_fd_sc_lp__and2_1_0/B
+ sky130_fd_sc_lp__and2_1
Xasyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 asyn_gr_counter_cell_1/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 asyn_gr_counter_cell_1/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 asyn_gr_counter_cell_1/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 asyn_gr_counter_cell_1/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_gr_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_2/sky130_fd_sc_lp__xor2_1_0 asyn_gr_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_gr_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd Q2 sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_2/sky130_fd_sc_lp__and2_1_0 asyn_gr_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_gr_counter_cell_2/sky130_fd_sc_lp__and2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_3/sky130_fd_sc_lp__and2_1_0/B
+ sky130_fd_sc_lp__and2_1
Xasyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 asyn_gr_counter_cell_2/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 asyn_gr_counter_cell_2/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 asyn_gr_counter_cell_2/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 asyn_gr_counter_cell_2/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_gr_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_3/sky130_fd_sc_lp__xor2_1_0 asyn_gr_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_gr_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd Q3 sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_3/sky130_fd_sc_lp__and2_1_0 asyn_gr_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_gr_counter_cell_3/sky130_fd_sc_lp__and2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_4/sky130_fd_sc_lp__and2_1_0/B
+ sky130_fd_sc_lp__and2_1
Xasyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 asyn_gr_counter_cell_3/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 asyn_gr_counter_cell_3/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 asyn_gr_counter_cell_3/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 asyn_gr_counter_cell_3/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_gr_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_5/sky130_fd_sc_lp__xor2_1_0 asyn_gr_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_gr_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd Q5 sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_5/sky130_fd_sc_lp__and2_1_0 asyn_gr_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_gr_counter_cell_5/sky130_fd_sc_lp__and2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_6/sky130_fd_sc_lp__and2_1_0/B
+ sky130_fd_sc_lp__and2_1
Xasyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 asyn_gr_counter_cell_5/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 asyn_gr_counter_cell_5/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 asyn_gr_counter_cell_5/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 asyn_gr_counter_cell_5/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_gr_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_4/sky130_fd_sc_lp__xor2_1_0 asyn_gr_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_gr_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd Q4 sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_4/sky130_fd_sc_lp__and2_1_0 asyn_gr_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_gr_counter_cell_4/sky130_fd_sc_lp__and2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_5/sky130_fd_sc_lp__and2_1_0/B
+ sky130_fd_sc_lp__and2_1
Xasyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 asyn_gr_counter_cell_4/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 asyn_gr_counter_cell_4/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 asyn_gr_counter_cell_4/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 asyn_gr_counter_cell_4/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_gr_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_6/sky130_fd_sc_lp__xor2_1_0 Q7 asyn_gr_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B
+ gnd gnd Vdd Vdd Q6 sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_6/sky130_fd_sc_lp__and2_1_0 asyn_gr_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_gr_counter_cell_6/sky130_fd_sc_lp__and2_1_0/B gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/A
+ sky130_fd_sc_lp__and2_1
Xasyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 asyn_gr_counter_cell_6/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 asyn_gr_counter_cell_6/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 asyn_gr_counter_cell_6/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 asyn_gr_counter_cell_6/sky130_fd_sc_lp__and2_1_0/B
+ asyn_gr_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_gr_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_gr_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
XT_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd Q7 sky130_fd_sc_lp__dfrtp_1
XT_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/A
+ Q7 gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X sky130_fd_sc_lp__xor2_1
XT_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/A
+ Q7 gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X sky130_fd_sc_lp__xor2_1
XT_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/A
+ Q7 gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X sky130_fd_sc_lp__xor2_1
XT_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/A
+ Q7 gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X sky130_fd_sc_lp__xor2_1
XT_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd Q7 sky130_fd_sc_lp__dfrtp_1
XT_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd Q7 sky130_fd_sc_lp__dfrtp_1
XT_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd Q7 sky130_fd_sc_lp__dfrtp_1

*.ends
