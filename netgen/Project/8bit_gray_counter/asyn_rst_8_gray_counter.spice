* SPICE3 file created from /home/sky/asyn_rst_8_gray_counter.ext - technology: sky130A

.option scale=5000u

*.subckt x/home/sky/asyn_rst_8_gray_counter RSTB CLK Vdd gnd
Xasyn_rst_counter_cell_1/sky130_fd_sc_lp__xor2_1_0 asyn_rst_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_rst_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_1/sky130_fd_sc_lp__and2_1_0 asyn_rst_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_rst_counter_cell_1/sky130_fd_sc_lp__and2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_2/sky130_fd_sc_lp__and2_1_0/B
+ sky130_fd_sc_lp__and2_1
Xasyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 asyn_rst_counter_cell_1/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 asyn_rst_counter_cell_1/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 asyn_rst_counter_cell_1/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 asyn_rst_counter_cell_1/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_rst_counter_cell_1/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_2/sky130_fd_sc_lp__xor2_1_0 asyn_rst_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_rst_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_2/sky130_fd_sc_lp__and2_1_0 asyn_rst_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_rst_counter_cell_2/sky130_fd_sc_lp__and2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_3/sky130_fd_sc_lp__and2_1_0/B
+ sky130_fd_sc_lp__and2_1
Xasyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 asyn_rst_counter_cell_2/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 asyn_rst_counter_cell_2/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 asyn_rst_counter_cell_2/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 asyn_rst_counter_cell_2/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_rst_counter_cell_2/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_2/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_3/sky130_fd_sc_lp__xor2_1_0 asyn_rst_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_rst_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_3/sky130_fd_sc_lp__and2_1_0 asyn_rst_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_rst_counter_cell_3/sky130_fd_sc_lp__and2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_4/sky130_fd_sc_lp__and2_1_0/B
+ sky130_fd_sc_lp__and2_1
Xasyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 asyn_rst_counter_cell_3/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 asyn_rst_counter_cell_3/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 asyn_rst_counter_cell_3/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 asyn_rst_counter_cell_3/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_rst_counter_cell_3/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_3/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_4/sky130_fd_sc_lp__xor2_1_0 asyn_rst_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_rst_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_4/sky130_fd_sc_lp__and2_1_0 asyn_rst_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_rst_counter_cell_4/sky130_fd_sc_lp__and2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_5/sky130_fd_sc_lp__and2_1_0/B
+ sky130_fd_sc_lp__and2_1
Xasyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 asyn_rst_counter_cell_4/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 asyn_rst_counter_cell_4/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 asyn_rst_counter_cell_4/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 asyn_rst_counter_cell_4/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_rst_counter_cell_4/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_4/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_5/sky130_fd_sc_lp__xor2_1_0 asyn_rst_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_rst_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_5/sky130_fd_sc_lp__and2_1_0 asyn_rst_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_rst_counter_cell_5/sky130_fd_sc_lp__and2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_6/sky130_fd_sc_lp__and2_1_0/B
+ sky130_fd_sc_lp__and2_1
Xasyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 asyn_rst_counter_cell_5/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 asyn_rst_counter_cell_5/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 asyn_rst_counter_cell_5/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 asyn_rst_counter_cell_5/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_rst_counter_cell_5/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_5/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_6/sky130_fd_sc_lp__xor2_1_0 T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/B
+ asyn_rst_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_6/sky130_fd_sc_lp__and2_1_0 asyn_rst_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_rst_counter_cell_6/sky130_fd_sc_lp__and2_1_0/B gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/A
+ sky130_fd_sc_lp__and2_1
Xasyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 asyn_rst_counter_cell_6/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 asyn_rst_counter_cell_6/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 asyn_rst_counter_cell_6/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 asyn_rst_counter_cell_6/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_rst_counter_cell_6/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_6/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
XT_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/B sky130_fd_sc_lp__dfrtp_1
XT_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/A
+ T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/B gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
XT_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/A
+ T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/B gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
XT_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/A
+ T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/B gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
XT_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/A
+ T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/B gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
XT_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/B sky130_fd_sc_lp__dfrtp_1
XT_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/B sky130_fd_sc_lp__dfrtp_1
XT_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_0/sky130_fd_sc_lp__xor2_1_0 asyn_rst_counter_cell_1/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_rst_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_0/sky130_fd_sc_lp__and2_1_0 asyn_rst_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B
+ asyn_rst_counter_cell_0/sky130_fd_sc_lp__and2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_1/sky130_fd_sc_lp__and2_1_0/B
+ sky130_fd_sc_lp__and2_1
Xasyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_3 CLK asyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_0 asyn_rst_counter_cell_0/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_1 asyn_rst_counter_cell_0/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_2 asyn_rst_counter_cell_0/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3 asyn_rst_counter_cell_0/sky130_fd_sc_lp__and2_1_0/B
+ asyn_rst_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B gnd gnd Vdd Vdd asyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ sky130_fd_sc_lp__xor2_1
Xasyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_0 CLK asyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_1 CLK asyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
Xasyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__dfrtp_1_2 CLK asyn_rst_counter_cell_0/T_flip_flop_0/sky130_fd_sc_lp__xor2_1_3/X
+ RSTB gnd gnd Vdd Vdd asyn_rst_counter_cell_0/sky130_fd_sc_lp__xor2_1_0/B sky130_fd_sc_lp__dfrtp_1
