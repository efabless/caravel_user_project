v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -6306028750 -1139383670 -6306028725 -1139383670 { lab=#net1}
N -6306028750 -1139383650 -6306028725 -1139383650 { lab=#net2}
N -6306028750 -1139383630 -6306028725 -1139383630 { lab=#net3}
N -6306029120 -1139383630 -6306029055 -1139383630 { lab=#net4}
N -6306029100 -1139383720 -6306029100 -1139383630 { lab=#net4}
N -6306029100 -1139383720 -6306028855 -1139383720 { lab=#net4}
N -6306028855 -1139383720 -6306028850 -1139383720 { lab=#net4}
N -6306028850 -1139383720 -6306028850 -1139383670 { lab=#net4}
N -6306028935 -1139383650 -6306028870 -1139383650 { lab=#net5}
N -6306028870 -1139383650 -6306028870 -1139383630 { lab=#net5}
N -6306028870 -1139383630 -6306028850 -1139383630 { lab=#net5}
N -6306028935 -1139383630 -6306028880 -1139383630 { lab=#net6}
N -6306028880 -1139383630 -6306028880 -1139383590 { lab=#net6}
N -6306028880 -1139383590 -6306028850 -1139383590 { lab=#net6}
N -6306028935 -1139383610 -6306028900 -1139383610 { lab=#net7}
N -6306028900 -1139383610 -6306028900 -1139383550 { lab=#net7}
N -6306028900 -1139383550 -6306028850 -1139383550 { lab=#net7}
N -6306029120 -1139383670 -6306029055 -1139383670 { lab=clk}
N -6306029055 -1139383710 -6306029055 -1139383670 { lab=clk}
N -6306029055 -1139383710 -6306028865 -1139383710 { lab=clk}
N -6306028865 -1139383710 -6306028865 -1139383650 { lab=clk}
N -6306028865 -1139383650 -6306028850 -1139383650 { lab=clk}
N -6306028935 -1139383670 -6306028900 -1139383670 { lab=#net8}
N -6306028900 -1139383670 -6306028890 -1139383670 { lab=#net8}
N -6306028890 -1139383670 -6306028890 -1139383610 { lab=#net8}
N -6306028890 -1139383610 -6306028850 -1139383610 { lab=#net8}
N -6306028870 -1139383630 -6306028870 -1139383570 { lab=#net5}
N -6306028870 -1139383570 -6306028850 -1139383570 { lab=#net5}
N -6306029015 -1139383730 -6306029015 -1139383700 { lab=VDD}
N -6306029015 -1139383740 -6306029015 -1139383730 { lab=VDD}
N -6306029020 -1139383740 -6306028645 -1139383740 { lab=VDD}
N -6306028645 -1139383740 -6306028645 -1139383710 { lab=VDD}
N -6306028820 -1139383740 -6306028820 -1139383700 { lab=VDD}
N -6306029120 -1139383740 -6306029020 -1139383740 { lab=VDD}
N -6306029120 -1139383760 -6306028595 -1139383760 { lab=GND}
N -6306028595 -1139383760 -6306028595 -1139383710 { lab=GND}
N -6306028780 -1139383760 -6306028780 -1139383700 { lab=GND}
N -6306028975 -1139383760 -6306028975 -1139383700 { lab=GND}
N -6306028515 -1139383670 -6306028430 -1139383670 { lab=#net9}
N -6306028515 -1139383650 -6306028480 -1139383650 { lab=#net10}
N -6306028480 -1139383650 -6306028480 -1139383340 { lab=#net10}
N -6306028480 -1139383340 -6306028480 -1139383335 { lab=#net10}
N -6306028480 -1139383335 -6306028435 -1139383335 { lab=#net10}
N -6306028515 -1139383630 -6306028500 -1139383630 { lab=#net11}
N -6306028515 -1139383610 -6306028500 -1139383610 { lab=#net12}
N -6306028515 -1139383590 -6306028500 -1139383590 { lab=#net13}
N -6306028515 -1139383570 -6306028500 -1139383570 { lab=#net14}
N -6306028515 -1139383550 -6306028500 -1139383550 { lab=#net15}
N -6306028515 -1139383530 -6306028500 -1139383530 { lab=#net16}
N -6306028435 -1139383650 -6306028435 -1139383410 { lab=in1}
N -6306028535 -1139383410 -6306028450 -1139383410 { lab=in1}
N -6306028445 -1139383410 -6306028435 -1139383410 { lab=in1}
N -6306028450 -1139383410 -6306028445 -1139383410 { lab=in1}
N -6306028175 -1139383670 -6306028155 -1139383670 { lab=e1_o}
N -6306028175 -1139383650 -6306028155 -1139383650 { lab=p1_o}
N -6306028175 -1139383630 -6306028155 -1139383630 { lab=e2_o}
N -6306028175 -1139383610 -6306028155 -1139383610 { lab=p2_o}
N -6306028175 -1139383590 -6306028155 -1139383590 { lab=e3_o}
N -6306028175 -1139383570 -6306028155 -1139383570 { lab=p3_o}
N -6306028175 -1139383550 -6306028155 -1139383550 { lab=e4_o}
N -6306028175 -1139383530 -6306028155 -1139383530 { lab=p4_o}
N -6306028175 -1139383510 -6306028155 -1139383510 { lab=e5_o}
N -6306028175 -1139383490 -6306028155 -1139383490 { lab=p5_o}
N -6306028175 -1139383470 -6306028155 -1139383470 { lab=e6_o}
N -6306028175 -1139383450 -6306028155 -1139383450 { lab=p6_o}
N -6306028435 -1139383315 -6306028435 -1139383075 { lab=in2}
N -6306028445 -1139383075 -6306028435 -1139383075 { lab=in2}
N -6306028450 -1139383075 -6306028445 -1139383075 { lab=in2}
N -6306028175 -1139383335 -6306028155 -1139383335 { lab=e1_o}
N -6306028175 -1139383315 -6306028155 -1139383315 { lab=p1_o2}
N -6306028175 -1139383295 -6306028155 -1139383295 { lab=e2_o2}
N -6306028175 -1139383275 -6306028155 -1139383275 { lab=p2_o2}
N -6306028175 -1139383255 -6306028155 -1139383255 { lab=e3_o2}
N -6306028175 -1139383235 -6306028155 -1139383235 { lab=p3_o2}
N -6306028175 -1139383215 -6306028155 -1139383215 { lab=e4_o2}
N -6306028175 -1139383195 -6306028155 -1139383195 { lab=p4_o2}
N -6306028175 -1139383175 -6306028155 -1139383175 { lab=e5_o2}
N -6306028175 -1139383155 -6306028155 -1139383155 { lab=p5_o2}
N -6306028175 -1139383135 -6306028155 -1139383135 { lab=e6_o2}
N -6306028175 -1139383115 -6306028155 -1139383115 { lab=p6_o2}
N -6306028540 -1139383410 -6306028535 -1139383410 { lab=in1}
N -6306029175 -1139383670 -6306029175 -1139383650 { lab=clk}
N -6306029175 -1139383670 -6306029120 -1139383670 { lab=clk}
N -6306028540 -1139383075 -6306028535 -1139383075 { lab=in2}
N -6306028535 -1139383075 -6306028450 -1139383075 { lab=in2}
N -6306028155 -1139383335 -6306028040 -1139383335 { lab=e1_o}
N -6306028155 -1139383670 -6306028040 -1139383670 { lab=e1_o}
N -6306028040 -1139383670 -6306028040 -1139383335 { lab=e1_o}
C {readout/counter_ro.sym} -4729542540 -854545170 0 0 {name=X1}
C {readout/3x8_decoder_ro.sym} -4729543095 -854544270 0 0 {name=X2}
C {readout/switch_ro.sym} -6306029395 -1139382910 0 0 {name=X4}
C {readout/fclk_tree.sym} -6306030485 -1139382490 0 0 {name=X5}
C {readout/switch_ro.sym} -6306029395 -1139382575 0 0 {name=X3}
C {devices/lab_pin.sym} -6306029175 -1139383670 0 0 {name=l3 sig_type=std_logic lab=clk}
C {devices/gnd.sym} -6306029175 -1139383590 0 0 {name=l89 lab=GND}
C {devices/vsource.sym} -6306029175 -1139383620 0 1 {name=V10 value="DC 0 PULSE(0 1.2 \{2/f\} 1n 1n \{duty_cycle*1/f\} \{1/f\})"}
C {devices/lab_pin.sym} -6306029120 -1139383740 0 0 {name=l4 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -6306029120 -1139383760 0 0 {name=l5 sig_type=std_logic lab=GND}
C {devices/vsource.sym} -6306029310 -1139383725 0 0 {name=V2 value=1.2}
C {devices/gnd.sym} -6306029310 -1139383695 0 0 {name=l13 lab=GND}
C {devices/vdd.sym} -6306029310 -1139383755 0 0 {name=l15 lab=VDD}
C {devices/vsource.sym} -6306029120 -1139383600 0 0 {name=V9 value="DC 0 PWL(0 0 2u 0 2.01u 1.2 10u 1.2)"}
C {devices/gnd.sym} -6306029120 -1139383570 0 0 {name=l88 lab=GND}
C {devices/lab_pin.sym} -6306028155 -1139383670 2 0 {name=l6 sig_type=std_logic lab=e1_o}
C {devices/lab_pin.sym} -6306028155 -1139383650 2 0 {name=l7 sig_type=std_logic lab=p1_o}
C {devices/lab_pin.sym} -6306028155 -1139383630 2 0 {name=l8 sig_type=std_logic lab=e2_o}
C {devices/lab_pin.sym} -6306028155 -1139383610 2 0 {name=l9 sig_type=std_logic lab=p2_o}
C {devices/lab_pin.sym} -6306028155 -1139383590 2 0 {name=l10 sig_type=std_logic lab=e3_o}
C {devices/lab_pin.sym} -6306028155 -1139383570 2 0 {name=l11 sig_type=std_logic lab=p3_o}
C {devices/lab_pin.sym} -6306028155 -1139383550 2 0 {name=l12 sig_type=std_logic lab=e4_o}
C {devices/lab_pin.sym} -6306028155 -1139383530 2 0 {name=l14 sig_type=std_logic lab=p4_o}
C {devices/lab_pin.sym} -6306028155 -1139383510 2 0 {name=l16 sig_type=std_logic lab=e5_o}
C {devices/lab_pin.sym} -6306028155 -1139383490 2 0 {name=l17 sig_type=std_logic lab=p5_o}
C {devices/lab_pin.sym} -6306028155 -1139383470 2 0 {name=l18 sig_type=std_logic lab=e6_o}
C {devices/lab_pin.sym} -6306028155 -1139383450 2 0 {name=l19 sig_type=std_logic lab=p6_o}
C {devices/lab_pin.sym} -6306028155 -1139383315 2 0 {name=l21 sig_type=std_logic lab=p1_o2}
C {devices/lab_pin.sym} -6306028155 -1139383295 2 0 {name=l22 sig_type=std_logic lab=e2_o2}
C {devices/lab_pin.sym} -6306028155 -1139383275 2 0 {name=l23 sig_type=std_logic lab=p2_o2}
C {devices/lab_pin.sym} -6306028155 -1139383255 2 0 {name=l24 sig_type=std_logic lab=e3_o2}
C {devices/lab_pin.sym} -6306028155 -1139383235 2 0 {name=l25 sig_type=std_logic lab=p3_o2}
C {devices/lab_pin.sym} -6306028155 -1139383215 2 0 {name=l26 sig_type=std_logic lab=e4_o2}
C {devices/lab_pin.sym} -6306028155 -1139383195 2 0 {name=l27 sig_type=std_logic lab=p4_o2}
C {devices/lab_pin.sym} -6306028155 -1139383175 2 0 {name=l28 sig_type=std_logic lab=e5_o2}
C {devices/lab_pin.sym} -6306028155 -1139383155 2 0 {name=l29 sig_type=std_logic lab=p5_o2}
C {devices/lab_pin.sym} -6306028155 -1139383135 2 0 {name=l30 sig_type=std_logic lab=e6_o2}
C {devices/lab_pin.sym} -6306028155 -1139383115 2 0 {name=l31 sig_type=std_logic lab=p6_o2}
C {devices/netlist.sym} -6306028080 -1139383870 0 0 {name=s1 value="
.lib /home/sky/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.include /home/sky/sky130A/libs.ref/sky130_fd_sc_lp/spice/sky130_fd_sc_lp.spice
.options abstol=1e-18 reltol=1e-4
.param f=2560k
.param duty_cycle=0.5
.tran \{(1/100)*(1/f)\} \{256/f\}
.save all
"}
C {devices/vsource.sym} -6306028540 -1139383380 0 0 {name=Vin value="DC 0 PULSE(1.2 0 1u 1u 1u 1m 2m)"
*DC 0 *DC 0 SIN(0.6 0.6 }
C {devices/gnd.sym} -6306028540 -1139383350 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -6306028540 -1139383410 0 0 {name=l33 sig_type=std_logic lab=in1}
C {devices/vsource.sym} -6306028540 -1139383045 0 0 {name=Vin1 value="DC 0 PULSE(0 1.2 1u 1u 1u 0.5m 1m)"
*DC 0 SIN(0.6 0.6 1k)}
C {devices/gnd.sym} -6306028540 -1139383015 0 0 {name=l34 lab=GND}
C {devices/lab_pin.sym} -6306028540 -1139383075 0 0 {name=l35 sig_type=std_logic lab=in2}
