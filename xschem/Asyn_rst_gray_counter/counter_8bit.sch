v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -10590 2590 -10470 2590 { lab=EN}
N -10470 2680 -10470 2740 { lab=#net1}
N -10470 2740 -10050 2740 { lab=#net1}
N -10050 2640 -10050 2740 { lab=#net1}
N -10290 2590 -10290 2600 { lab=#net2}
N -10290 2590 -10230 2590 { lab=#net2}
N -10290 2640 -10280 2640 { lab=#net3}
N -10050 2590 -10050 2600 { lab=#net4}
N -10050 2590 -10000 2590 { lab=#net4}
N -9820 2590 -9820 2600 { lab=#net5}
N -9820 2590 -9770 2590 { lab=#net5}
N -9590 2590 -9590 2600 { lab=#net6}
N -9590 2590 -9510 2590 { lab=#net6}
N -9330 2590 -9330 2600 { lab=#net7}
N -9330 2590 -9280 2590 { lab=#net7}
N -9100 2590 -9100 2600 { lab=#net8}
N -9100 2590 -9050 2590 { lab=#net8}
N -10230 2680 -10230 2730 { lab=#net9}
N -10230 2730 -9820 2730 { lab=#net9}
N -9820 2640 -9820 2730 { lab=#net9}
N -10000 2680 -10000 2740 { lab=#net10}
N -10000 2740 -9590 2740 { lab=#net10}
N -9590 2640 -9590 2740 { lab=#net10}
N -9770 2680 -9770 2730 { lab=#net11}
N -9770 2730 -9330 2730 { lab=#net11}
N -9330 2640 -9330 2730 { lab=#net11}
N -9510 2680 -9510 2740 { lab=#net12}
N -9510 2740 -9100 2740 { lab=#net12}
N -9100 2640 -9100 2740 { lab=#net12}
N -9280 2680 -9280 2730 { lab=#net13}
N -9280 2730 -8870 2730 { lab=#net13}
N -8870 2640 -8870 2730 { lab=#net13}
N -10590 2790 -8810 2790 { lab=Clk}
N -10260 2620 -10230 2620 { lab=Clk}
N -10260 2620 -10260 2790 { lab=Clk}
N -10240 2650 -10230 2650 { lab=RST_bar}
N -10240 2650 -10240 2760 { lab=RST_bar}
N -10030 2620 -10000 2620 { lab=Clk}
N -10030 2620 -10030 2790 { lab=Clk}
N -10010 2650 -10000 2650 { lab=RST_bar}
N -10010 2650 -10010 2760 { lab=RST_bar}
N -9800 2620 -9770 2620 { lab=Clk}
N -9800 2620 -9800 2790 { lab=Clk}
N -9780 2650 -9770 2650 { lab=RST_bar}
N -9780 2650 -9780 2760 { lab=RST_bar}
N -9550 2620 -9510 2620 { lab=Clk}
N -9550 2620 -9550 2790 { lab=Clk}
N -9520 2650 -9510 2650 { lab=RST_bar}
N -9520 2650 -9520 2760 { lab=RST_bar}
N -9310 2620 -9280 2620 { lab=Clk}
N -9310 2620 -9310 2790 { lab=Clk}
N -9290 2650 -9280 2650 { lab=RST_bar}
N -9290 2650 -9290 2760 { lab=RST_bar}
N -9080 2620 -9050 2620 { lab=Clk}
N -9080 2620 -9080 2790 { lab=Clk}
N -9060 2650 -9050 2650 { lab=RST_bar}
N -9060 2650 -9060 2760 { lab=RST_bar}
N -8870 2600 -8820 2600 { lab=#net14}
N -8820 2700 -8820 2760 { lab=RST_bar}
N -10590 2760 -8820 2760 { lab=RST_bar}
N -8710 2770 -8710 2790 { lab=Clk}
N -8810 2790 -8710 2790 { lab=Clk}
N -8600 2600 -8600 2820 { lab=Q7}
N -10290 2620 -10280 2620 { lab=Q0}
N -10280 2620 -10270 2620 { lab=Q0}
N -10270 2620 -10270 2820 { lab=Q0}
N -10050 2620 -10040 2620 { lab=Q1}
N -10040 2620 -10040 2820 { lab=Q1}
N -9820 2620 -9810 2620 { lab=Q2}
N -9810 2620 -9810 2820 { lab=Q2}
N -9590 2620 -9570 2620 { lab=Q3}
N -9570 2620 -9570 2820 { lab=Q3}
N -9330 2620 -9320 2620 { lab=Q4}
N -9320 2620 -9320 2820 { lab=Q4}
N -9100 2620 -9090 2620 { lab=Q5}
N -9090 2620 -9090 2820 { lab=Q5}
N -8870 2620 -8850 2620 { lab=Q6}
N -8850 2620 -8850 2820 { lab=Q6}
N -10490 2650 -10470 2650 { lab=RST_bar}
N -10490 2650 -10490 2760 { lab=RST_bar}
N -10510 2620 -10470 2620 { lab=Clk}
N -10510 2620 -10510 2790 { lab=Clk}
N -9050 2680 -9050 2780 { lab=Q7}
N -9050 2780 -8600 2780 { lab=Q7}
N -10590 2500 -8680 2500 { lab=VDD}
N -8680 2500 -8680 2540 { lab=VDD}
N -8740 2470 -8740 2540 { lab=VDD}
N -10590 2470 -8740 2470 { lab=VDD}
N -10410 2470 -10410 2540 { lab=VDD}
N -10350 2500 -10350 2540 { lab=VDD}
N -10170 2470 -10170 2540 { lab=VDD}
N -10110 2500 -10110 2540 { lab=VDD}
N -9940 2470 -9940 2540 { lab=VDD}
N -9880 2500 -9880 2540 { lab=VDD}
N -9710 2470 -9710 2540 { lab=VDD}
N -9650 2500 -9650 2540 { lab=VDD}
N -9450 2470 -9450 2540 { lab=VDD}
N -9390 2500 -9390 2540 { lab=VDD}
N -9220 2470 -9220 2540 { lab=VDD}
N -9160 2500 -9160 2540 { lab=VDD}
N -8990 2470 -8990 2540 { lab=VDD}
N -8930 2500 -8930 2540 { lab=VDD}
C {Asyn_rst_gray_counter/counter_cell.sym} -5670 1740 0 0 {name=X1}
C {Asyn_rst_gray_counter/counter_cell.sym} -5430 1740 0 0 {name=X2}
C {Asyn_rst_gray_counter/counter_cell.sym} -5200 1740 0 0 {name=X3}
C {Asyn_rst_gray_counter/counter_cell.sym} -4970 1740 0 0 {name=X4}
C {Asyn_rst_gray_counter/counter_cell.sym} -4710 1740 0 0 {name=X5}
C {Asyn_rst_gray_counter/counter_cell.sym} -4480 1740 0 0 {name=X6}
C {Asyn_rst_gray_counter/counter_cell.sym} -4250 1740 0 0 {name=X7}
C {T_flip_flop/asyn_rst_t_ff.sym} -7770 3020 0 0 {name=X8}
C {devices/ipin.sym} -10580 2590 0 0 {name=p2 lab=EN}
C {devices/ipin.sym} -10580 2760 0 0 {name=p22 lab=RST_bar}
C {devices/ipin.sym} -10580 2790 0 0 {name=p11 lab=Clk}
C {devices/opin.sym} -10270 2810 1 0 {name=p13 lab=Q0}
C {devices/opin.sym} -10040 2810 1 0 {name=p1 lab=Q1}
C {devices/opin.sym} -9810 2810 1 0 {name=p3 lab=Q2}
C {devices/opin.sym} -9570 2810 1 0 {name=p4 lab=Q3}
C {devices/opin.sym} -9320 2810 1 0 {name=p5 lab=Q4}
C {devices/opin.sym} -9090 2810 1 0 {name=p6 lab=Q5}
C {devices/opin.sym} -8850 2810 1 0 {name=p7 lab=Q6}
C {devices/opin.sym} -8600 2810 1 0 {name=p8 lab=Q7}
C {devices/iopin.sym} -10580 2470 2 0 {name=p9 lab=GND}
C {devices/iopin.sym} -10580 2500 2 0 {name=p10 lab=VDD}
