v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {sky130_stdcells/dfxtp_1.sym} 130 -60 0 0 {name=x1 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_lp__ }
C {devices/ipin.sym} 40 -70 0 0 {name=p1 lab=clk}
C {devices/ipin.sym} 40 -50 0 0 {name=p2 lab=D}
C {devices/opin.sym} 220 -70 0 0 {name=p3 lab=Q}
