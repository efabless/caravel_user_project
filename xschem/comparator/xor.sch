v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {sky130_stdcells/xor2_1.sym} 170 -160 0 0 {name=x1 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/ipin.sym} 110 -180 0 0 {name=p1 lab=A}
C {devices/ipin.sym} 110 -140 0 0 {name=p2 lab=B}
C {devices/opin.sym} 230 -160 0 0 {name=p3 lab=X}
