v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 3330 -780 3480 -780 { lab=#net1}
N 3390 -840 3400 -840 { lab=#net1}
N 3400 -840 3400 -780 { lab=#net1}
N 3320 -780 3330 -780 { lab=#net1}
N 3330 -860 3330 -840 { lab=VDD}
N 3320 -700 3330 -700 { lab=#net2}
N 3390 -700 3480 -700 { lab=#net3}
N 3360 -800 3360 -740 { lab=#net4}
N 3360 -700 3360 -680 { lab=#net4}
N 3360 -890 3360 -830 { lab=#net4}
N 3300 -860 3480 -860 { lab=VDD}
N 3440 -880 3440 -680 { lab=#net5}
N 3360 -740 3360 -700 { lab=#net4}
N 3360 -830 3360 -800 { lab=#net4}
N 3300 -700 3320 -700 { lab=#net2}
N 3300 -780 3320 -780 { lab=#net1}
N 3510 -780 3660 -780 { lab=#net1}
N 3570 -840 3580 -840 { lab=#net1}
N 3580 -840 3580 -780 { lab=#net1}
N 3500 -780 3510 -780 { lab=#net1}
N 3510 -860 3510 -840 { lab=VDD}
N 3500 -700 3510 -700 { lab=#net3}
N 3570 -700 3660 -700 { lab=#net6}
N 3540 -800 3540 -740 { lab=#net7}
N 3540 -700 3540 -680 { lab=#net7}
N 3540 -890 3540 -830 { lab=#net7}
N 3480 -860 3660 -860 { lab=VDD}
N 3620 -880 3620 -680 { lab=#net8}
N 3540 -740 3540 -700 { lab=#net7}
N 3540 -830 3540 -800 { lab=#net7}
N 3480 -700 3500 -700 { lab=#net3}
N 3480 -780 3500 -780 { lab=#net1}
N 3690 -780 3840 -780 { lab=#net1}
N 3750 -840 3760 -840 { lab=#net1}
N 3760 -840 3760 -780 { lab=#net1}
N 3680 -780 3690 -780 { lab=#net1}
N 3690 -860 3690 -840 { lab=VDD}
N 3680 -700 3690 -700 { lab=#net6}
N 3750 -700 3840 -700 { lab=#net9}
N 3720 -800 3720 -740 { lab=#net10}
N 3720 -700 3720 -680 { lab=#net10}
N 3720 -890 3720 -830 { lab=#net10}
N 3660 -860 3840 -860 { lab=VDD}
N 3800 -880 3800 -680 { lab=#net11}
N 3720 -740 3720 -700 { lab=#net10}
N 3720 -830 3720 -800 { lab=#net10}
N 3660 -700 3680 -700 { lab=#net6}
N 3660 -780 3680 -780 { lab=#net1}
N 4000 -840 4010 -840 { lab=VDD}
N 4010 -860 4010 -840 { lab=VDD}
N 3980 -800 3980 -740 { lab=#net12}
N 3980 -700 3980 -680 { lab=#net12}
N 3980 -890 3980 -830 { lab=#net12}
N 3980 -740 3980 -700 { lab=#net12}
N 3980 -830 3980 -800 { lab=#net12}
N 3900 -890 3900 -680 { lab=#net13}
N 3840 -780 4020 -780 { lab=#net1}
N 3940 -840 3950 -840 { lab=#net1}
N 3940 -840 3940 -780 { lab=#net1}
N 3840 -700 3950 -700 { lab=#net9}
N 4010 -700 4020 -700 { lab=#net14}
N 3840 -860 4020 -860 { lab=VDD}
N 4180 -840 4190 -840 { lab=VDD}
N 4190 -860 4190 -840 { lab=VDD}
N 4160 -800 4160 -740 { lab=#net15}
N 4160 -700 4160 -680 { lab=#net15}
N 4160 -890 4160 -830 { lab=#net15}
N 4160 -740 4160 -700 { lab=#net15}
N 4160 -830 4160 -800 { lab=#net15}
N 4080 -890 4080 -680 { lab=#net16}
N 4020 -780 4200 -780 { lab=#net1}
N 4120 -840 4130 -840 { lab=#net1}
N 4120 -840 4120 -780 { lab=#net1}
N 4020 -700 4130 -700 { lab=#net14}
N 4190 -700 4200 -700 { lab=#net1}
N 4020 -860 4200 -860 { lab=VDD}
N 3150 -780 3300 -780 { lab=#net1}
N 3210 -840 3220 -840 { lab=#net1}
N 3220 -840 3220 -780 { lab=#net1}
N 3140 -780 3150 -780 { lab=#net1}
N 3150 -860 3150 -840 { lab=VDD}
N 3140 -700 3150 -700 { lab=GND}
N 3210 -700 3300 -700 { lab=#net2}
N 3180 -800 3180 -740 { lab=#net17}
N 3180 -700 3180 -680 { lab=#net17}
N 3180 -890 3180 -830 { lab=#net17}
N 3120 -860 3300 -860 { lab=VDD}
N 3260 -880 3260 -680 { lab=#net18}
N 3180 -740 3180 -700 { lab=#net17}
N 3180 -830 3180 -800 { lab=#net17}
N 3120 -700 3140 -700 { lab=GND}
N 3120 -780 3140 -780 { lab=#net1}
N 3330 -570 3480 -570 { lab=#net19}
N 3390 -630 3400 -630 { lab=#net19}
N 3400 -630 3400 -570 { lab=#net19}
N 3320 -570 3330 -570 { lab=#net19}
N 3330 -650 3330 -630 { lab=VDD}
N 3320 -490 3330 -490 { lab=#net20}
N 3390 -490 3480 -490 { lab=#net21}
N 3360 -590 3360 -530 { lab=#net4}
N 3360 -490 3360 -470 { lab=#net4}
N 3360 -680 3360 -620 { lab=#net4}
N 3300 -650 3480 -650 { lab=VDD}
N 3440 -670 3440 -470 { lab=#net5}
N 3360 -530 3360 -490 { lab=#net4}
N 3360 -620 3360 -590 { lab=#net4}
N 3300 -490 3320 -490 { lab=#net20}
N 3300 -570 3320 -570 { lab=#net19}
N 3510 -570 3660 -570 { lab=#net19}
N 3570 -630 3580 -630 { lab=#net19}
N 3580 -630 3580 -570 { lab=#net19}
N 3500 -570 3510 -570 { lab=#net19}
N 3510 -650 3510 -630 { lab=VDD}
N 3500 -490 3510 -490 { lab=#net21}
N 3570 -490 3660 -490 { lab=#net22}
N 3540 -590 3540 -530 { lab=#net7}
N 3540 -490 3540 -470 { lab=#net7}
N 3540 -680 3540 -620 { lab=#net7}
N 3480 -650 3660 -650 { lab=VDD}
N 3620 -670 3620 -470 { lab=#net8}
N 3540 -530 3540 -490 { lab=#net7}
N 3540 -620 3540 -590 { lab=#net7}
N 3480 -490 3500 -490 { lab=#net21}
N 3480 -570 3500 -570 { lab=#net19}
N 3690 -570 3840 -570 { lab=#net19}
N 3750 -630 3760 -630 { lab=#net19}
N 3760 -630 3760 -570 { lab=#net19}
N 3680 -570 3690 -570 { lab=#net19}
N 3690 -650 3690 -630 { lab=VDD}
N 3680 -490 3690 -490 { lab=#net22}
N 3750 -490 3840 -490 { lab=#net23}
N 3720 -590 3720 -530 { lab=#net10}
N 3720 -490 3720 -470 { lab=#net10}
N 3720 -680 3720 -620 { lab=#net10}
N 3660 -650 3840 -650 { lab=VDD}
N 3800 -670 3800 -470 { lab=#net11}
N 3720 -530 3720 -490 { lab=#net10}
N 3720 -620 3720 -590 { lab=#net10}
N 3660 -490 3680 -490 { lab=#net22}
N 3660 -570 3680 -570 { lab=#net19}
N 4000 -630 4010 -630 { lab=VDD}
N 4010 -650 4010 -630 { lab=VDD}
N 3980 -590 3980 -530 { lab=#net12}
N 3980 -490 3980 -470 { lab=#net12}
N 3980 -680 3980 -620 { lab=#net12}
N 3980 -530 3980 -490 { lab=#net12}
N 3980 -620 3980 -590 { lab=#net12}
N 3900 -680 3900 -470 { lab=#net13}
N 3840 -570 4020 -570 { lab=#net19}
N 3940 -630 3950 -630 { lab=#net19}
N 3940 -630 3940 -570 { lab=#net19}
N 3840 -490 3950 -490 { lab=#net23}
N 4010 -490 4020 -490 { lab=#net24}
N 3840 -650 4020 -650 { lab=VDD}
N 3150 -570 3300 -570 { lab=#net19}
N 3210 -630 3220 -630 { lab=#net19}
N 3220 -630 3220 -570 { lab=#net19}
N 3140 -570 3150 -570 { lab=#net19}
N 3150 -650 3150 -630 { lab=VDD}
N 3140 -490 3150 -490 { lab=GND}
N 3210 -490 3300 -490 { lab=#net20}
N 3180 -590 3180 -530 { lab=#net17}
N 3180 -490 3180 -470 { lab=#net17}
N 3180 -680 3180 -620 { lab=#net17}
N 3120 -650 3300 -650 { lab=VDD}
N 3260 -670 3260 -470 { lab=#net18}
N 3180 -530 3180 -490 { lab=#net17}
N 3180 -620 3180 -590 { lab=#net17}
N 3120 -490 3140 -490 { lab=GND}
N 3120 -570 3140 -570 { lab=#net19}
N 4050 -570 4200 -570 { lab=#net19}
N 4110 -630 4120 -630 { lab=#net19}
N 4120 -630 4120 -570 { lab=#net19}
N 4040 -570 4050 -570 { lab=#net19}
N 4050 -650 4050 -630 { lab=VDD}
N 4040 -490 4050 -490 { lab=#net24}
N 4110 -490 4200 -490 { lab=#net19}
N 4080 -590 4080 -530 { lab=#net16}
N 4080 -490 4080 -470 { lab=#net16}
N 4080 -680 4080 -620 { lab=#net16}
N 4020 -650 4200 -650 { lab=VDD}
N 4160 -670 4160 -470 { lab=#net15}
N 4080 -530 4080 -490 { lab=#net16}
N 4080 -620 4080 -590 { lab=#net16}
N 4020 -490 4040 -490 { lab=#net24}
N 4020 -570 4040 -570 { lab=#net19}
N 4160 -680 4160 -670 { lab=#net15}
N 3800 -680 3800 -670 { lab=#net11}
N 3620 -680 3620 -670 { lab=#net8}
N 3440 -680 3440 -670 { lab=#net5}
N 3260 -680 3260 -670 { lab=#net18}
N 3260 -890 3260 -880 { lab=#net18}
N 3440 -890 3440 -880 { lab=#net5}
N 3620 -890 3620 -880 { lab=#net8}
N 3800 -890 3800 -880 { lab=#net11}
N 3330 -360 3480 -360 { lab=#net25}
N 3390 -420 3400 -420 { lab=#net25}
N 3400 -420 3400 -360 { lab=#net25}
N 3320 -360 3330 -360 { lab=#net25}
N 3330 -440 3330 -420 { lab=VDD}
N 3320 -280 3330 -280 { lab=#net26}
N 3390 -280 3480 -280 { lab=#net27}
N 3360 -380 3360 -320 { lab=#net4}
N 3360 -280 3360 -260 { lab=#net4}
N 3360 -470 3360 -410 { lab=#net4}
N 3300 -440 3480 -440 { lab=VDD}
N 3440 -460 3440 -260 { lab=#net5}
N 3360 -320 3360 -280 { lab=#net4}
N 3360 -410 3360 -380 { lab=#net4}
N 3300 -280 3320 -280 { lab=#net26}
N 3300 -360 3320 -360 { lab=#net25}
N 3510 -360 3660 -360 { lab=#net25}
N 3570 -420 3580 -420 { lab=#net25}
N 3580 -420 3580 -360 { lab=#net25}
N 3500 -360 3510 -360 { lab=#net25}
N 3510 -440 3510 -420 { lab=VDD}
N 3500 -280 3510 -280 { lab=#net27}
N 3570 -280 3660 -280 { lab=#net28}
N 3540 -380 3540 -320 { lab=#net7}
N 3540 -280 3540 -260 { lab=#net7}
N 3540 -470 3540 -410 { lab=#net7}
N 3480 -440 3660 -440 { lab=VDD}
N 3620 -460 3620 -260 { lab=#net8}
N 3540 -320 3540 -280 { lab=#net7}
N 3540 -410 3540 -380 { lab=#net7}
N 3480 -280 3500 -280 { lab=#net27}
N 3480 -360 3500 -360 { lab=#net25}
N 3150 -360 3300 -360 { lab=#net25}
N 3210 -420 3220 -420 { lab=#net25}
N 3220 -420 3220 -360 { lab=#net25}
N 3140 -360 3150 -360 { lab=#net25}
N 3150 -440 3150 -420 { lab=VDD}
N 3140 -280 3150 -280 { lab=GND}
N 3210 -280 3300 -280 { lab=#net26}
N 3180 -380 3180 -320 { lab=#net17}
N 3180 -280 3180 -260 { lab=#net17}
N 3180 -470 3180 -410 { lab=#net17}
N 3120 -440 3300 -440 { lab=VDD}
N 3260 -460 3260 -260 { lab=#net18}
N 3180 -320 3180 -280 { lab=#net17}
N 3180 -410 3180 -380 { lab=#net17}
N 3120 -280 3140 -280 { lab=GND}
N 3120 -360 3140 -360 { lab=#net25}
N 3260 -470 3260 -460 { lab=#net18}
N 3440 -470 3440 -460 { lab=#net5}
N 3620 -470 3620 -460 { lab=#net8}
N 3820 -420 3830 -420 { lab=VDD}
N 3830 -440 3830 -420 { lab=VDD}
N 3800 -380 3800 -320 { lab=#net11}
N 3800 -280 3800 -260 { lab=#net11}
N 3800 -470 3800 -410 { lab=#net11}
N 3800 -320 3800 -280 { lab=#net11}
N 3800 -410 3800 -380 { lab=#net11}
N 3720 -470 3720 -260 { lab=#net10}
N 3660 -360 3840 -360 { lab=#net25}
N 3760 -420 3770 -420 { lab=#net25}
N 3760 -420 3760 -360 { lab=#net25}
N 3660 -280 3770 -280 { lab=#net28}
N 3830 -280 3840 -280 { lab=#net29}
N 3660 -440 3840 -440 { lab=VDD}
N 4000 -420 4010 -420 { lab=VDD}
N 4010 -440 4010 -420 { lab=VDD}
N 3980 -380 3980 -320 { lab=#net12}
N 3980 -280 3980 -260 { lab=#net12}
N 3980 -470 3980 -410 { lab=#net12}
N 3980 -320 3980 -280 { lab=#net12}
N 3980 -410 3980 -380 { lab=#net12}
N 3900 -470 3900 -260 { lab=#net13}
N 3840 -360 4020 -360 { lab=#net25}
N 3940 -420 3950 -420 { lab=#net25}
N 3940 -420 3940 -360 { lab=#net25}
N 3840 -280 3950 -280 { lab=#net29}
N 4010 -280 4020 -280 { lab=#net30}
N 3840 -440 4020 -440 { lab=VDD}
N 4050 -360 4200 -360 { lab=#net25}
N 4110 -420 4120 -420 { lab=#net25}
N 4120 -420 4120 -360 { lab=#net25}
N 4040 -360 4050 -360 { lab=#net25}
N 4050 -440 4050 -420 { lab=VDD}
N 4040 -280 4050 -280 { lab=#net30}
N 4110 -280 4200 -280 { lab=#net25}
N 4080 -380 4080 -320 { lab=#net16}
N 4080 -280 4080 -260 { lab=#net16}
N 4080 -470 4080 -410 { lab=#net16}
N 4020 -440 4200 -440 { lab=VDD}
N 4160 -460 4160 -260 { lab=#net15}
N 4080 -320 4080 -280 { lab=#net16}
N 4080 -410 4080 -380 { lab=#net16}
N 4020 -280 4040 -280 { lab=#net30}
N 4020 -360 4040 -360 { lab=#net25}
N 4160 -470 4160 -460 { lab=#net15}
N 3150 -150 3300 -150 { lab=#net31}
N 3210 -210 3220 -210 { lab=#net31}
N 3220 -210 3220 -150 { lab=#net31}
N 3140 -150 3150 -150 { lab=#net31}
N 3150 -230 3150 -210 { lab=VDD}
N 3140 -70 3150 -70 { lab=GND}
N 3210 -70 3300 -70 { lab=#net32}
N 3180 -170 3180 -110 { lab=#net17}
N 3180 -70 3180 -50 { lab=#net17}
N 3180 -260 3180 -200 { lab=#net17}
N 3120 -230 3300 -230 { lab=VDD}
N 3260 -250 3260 -50 { lab=#net18}
N 3180 -110 3180 -70 { lab=#net17}
N 3180 -200 3180 -170 { lab=#net17}
N 3120 -70 3140 -70 { lab=GND}
N 3120 -150 3140 -150 { lab=#net31}
N 3260 -260 3260 -250 { lab=#net18}
N 3330 -150 3480 -150 { lab=#net31}
N 3390 -210 3400 -210 { lab=#net31}
N 3400 -210 3400 -150 { lab=#net31}
N 3320 -150 3330 -150 { lab=#net31}
N 3330 -230 3330 -210 { lab=VDD}
N 3320 -70 3330 -70 { lab=#net32}
N 3390 -70 3480 -70 { lab=#net33}
N 3360 -170 3360 -110 { lab=#net4}
N 3360 -70 3360 -50 { lab=#net4}
N 3360 -260 3360 -200 { lab=#net4}
N 3300 -230 3480 -230 { lab=VDD}
N 3440 -250 3440 -50 { lab=#net5}
N 3360 -110 3360 -70 { lab=#net4}
N 3360 -200 3360 -170 { lab=#net4}
N 3300 -70 3320 -70 { lab=#net32}
N 3300 -150 3320 -150 { lab=#net31}
N 3440 -260 3440 -250 { lab=#net5}
N 3640 -210 3650 -210 { lab=VDD}
N 3650 -230 3650 -210 { lab=VDD}
N 3620 -170 3620 -110 { lab=#net8}
N 3620 -70 3620 -50 { lab=#net8}
N 3620 -260 3620 -200 { lab=#net8}
N 3620 -110 3620 -70 { lab=#net8}
N 3620 -200 3620 -170 { lab=#net8}
N 3540 -260 3540 -50 { lab=#net7}
N 3480 -150 3660 -150 { lab=#net31}
N 3580 -210 3590 -210 { lab=#net31}
N 3580 -210 3580 -150 { lab=#net31}
N 3480 -70 3590 -70 { lab=#net33}
N 3650 -70 3660 -70 { lab=#net34}
N 3480 -230 3660 -230 { lab=VDD}
N 3820 -210 3830 -210 { lab=VDD}
N 3830 -230 3830 -210 { lab=VDD}
N 3800 -170 3800 -110 { lab=#net11}
N 3800 -70 3800 -50 { lab=#net11}
N 3800 -260 3800 -200 { lab=#net11}
N 3800 -110 3800 -70 { lab=#net11}
N 3800 -200 3800 -170 { lab=#net11}
N 3720 -260 3720 -50 { lab=#net10}
N 3660 -150 3840 -150 { lab=#net31}
N 3760 -210 3770 -210 { lab=#net31}
N 3760 -210 3760 -150 { lab=#net31}
N 3660 -70 3770 -70 { lab=#net34}
N 3830 -70 3840 -70 { lab=#net35}
N 3660 -230 3840 -230 { lab=VDD}
N 3870 -150 4020 -150 { lab=#net31}
N 3930 -210 3940 -210 { lab=#net31}
N 3940 -210 3940 -150 { lab=#net31}
N 3860 -150 3870 -150 { lab=#net31}
N 3870 -230 3870 -210 { lab=VDD}
N 3860 -70 3870 -70 { lab=#net35}
N 3930 -70 4020 -70 { lab=#net36}
N 3900 -170 3900 -110 { lab=#net13}
N 3900 -70 3900 -50 { lab=#net13}
N 3900 -260 3900 -200 { lab=#net13}
N 3840 -230 4020 -230 { lab=VDD}
N 3980 -250 3980 -50 { lab=#net12}
N 3900 -110 3900 -70 { lab=#net13}
N 3900 -200 3900 -170 { lab=#net13}
N 3840 -70 3860 -70 { lab=#net35}
N 3840 -150 3860 -150 { lab=#net31}
N 3980 -260 3980 -250 { lab=#net12}
N 4180 -210 4190 -210 { lab=VDD}
N 4190 -230 4190 -210 { lab=VDD}
N 4160 -170 4160 -110 { lab=#net15}
N 4160 -70 4160 -50 { lab=#net15}
N 4160 -260 4160 -200 { lab=#net15}
N 4160 -110 4160 -70 { lab=#net15}
N 4160 -200 4160 -170 { lab=#net15}
N 4080 -260 4080 -50 { lab=#net16}
N 4020 -150 4200 -150 { lab=#net31}
N 4120 -210 4130 -210 { lab=#net31}
N 4120 -210 4120 -150 { lab=#net31}
N 4020 -70 4130 -70 { lab=#net36}
N 4190 -70 4200 -70 { lab=#net31}
N 4020 -230 4200 -230 { lab=VDD}
N 4200 -780 4260 -780 { lab=#net1}
N 4200 -700 4260 -700 { lab=#net1}
N 3150 60 3300 60 { lab=#net37}
N 3210 0 3220 0 { lab=#net37}
N 3220 0 3220 60 { lab=#net37}
N 3140 60 3150 60 { lab=#net37}
N 3150 -20 3150 0 { lab=VDD}
N 3140 140 3150 140 { lab=GND}
N 3210 140 3300 140 { lab=#net38}
N 3180 40 3180 100 { lab=#net17}
N 3180 140 3180 160 { lab=#net17}
N 3180 -50 3180 10 { lab=#net17}
N 3120 -20 3300 -20 { lab=VDD}
N 3260 -40 3260 160 { lab=#net18}
N 3180 100 3180 140 { lab=#net17}
N 3180 10 3180 40 { lab=#net17}
N 3120 140 3140 140 { lab=GND}
N 3120 60 3140 60 { lab=#net37}
N 3260 -50 3260 -40 { lab=#net18}
N 3330 60 3480 60 { lab=#net37}
N 3390 0 3400 0 { lab=#net37}
N 3400 0 3400 60 { lab=#net37}
N 3320 60 3330 60 { lab=#net37}
N 3330 -20 3330 0 { lab=VDD}
N 3320 140 3330 140 { lab=#net38}
N 3390 140 3480 140 { lab=#net39}
N 3360 40 3360 100 { lab=#net4}
N 3360 140 3360 160 { lab=#net4}
N 3360 -50 3360 10 { lab=#net4}
N 3300 -20 3480 -20 { lab=VDD}
N 3440 -40 3440 160 { lab=#net5}
N 3360 100 3360 140 { lab=#net4}
N 3360 10 3360 40 { lab=#net4}
N 3300 140 3320 140 { lab=#net38}
N 3300 60 3320 60 { lab=#net37}
N 3440 -50 3440 -40 { lab=#net5}
N 3640 0 3650 0 { lab=VDD}
N 3650 -20 3650 0 { lab=VDD}
N 3620 40 3620 100 { lab=#net8}
N 3620 140 3620 160 { lab=#net8}
N 3620 -50 3620 10 { lab=#net8}
N 3620 100 3620 140 { lab=#net8}
N 3620 10 3620 40 { lab=#net8}
N 3540 -50 3540 160 { lab=#net7}
N 3480 60 3660 60 { lab=#net37}
N 3580 0 3590 0 { lab=#net37}
N 3580 0 3580 60 { lab=#net37}
N 3480 140 3590 140 { lab=#net39}
N 3650 140 3660 140 { lab=#net40}
N 3480 -20 3660 -20 { lab=VDD}
N 3820 0 3830 0 { lab=VDD}
N 3830 -20 3830 0 { lab=VDD}
N 3800 40 3800 100 { lab=#net11}
N 3800 140 3800 160 { lab=#net11}
N 3800 -50 3800 10 { lab=#net11}
N 3800 100 3800 140 { lab=#net11}
N 3800 10 3800 40 { lab=#net11}
N 3720 -50 3720 160 { lab=#net10}
N 3660 60 3840 60 { lab=#net37}
N 3760 0 3770 0 { lab=#net37}
N 3760 0 3760 60 { lab=#net37}
N 3660 140 3770 140 { lab=#net40}
N 3830 140 3840 140 { lab=#net41}
N 3660 -20 3840 -20 { lab=VDD}
N 4000 0 4010 0 { lab=VDD}
N 4010 -20 4010 0 { lab=VDD}
N 3980 40 3980 100 { lab=#net12}
N 3980 140 3980 160 { lab=#net12}
N 3980 -50 3980 10 { lab=#net12}
N 3980 100 3980 140 { lab=#net12}
N 3980 10 3980 40 { lab=#net12}
N 3900 -50 3900 160 { lab=#net13}
N 3840 60 4020 60 { lab=#net37}
N 3940 0 3950 0 { lab=#net37}
N 3940 0 3940 60 { lab=#net37}
N 3840 140 3950 140 { lab=#net41}
N 4010 140 4020 140 { lab=#net42}
N 3840 -20 4020 -20 { lab=VDD}
N 4180 0 4190 0 { lab=VDD}
N 4190 -20 4190 0 { lab=VDD}
N 4160 40 4160 100 { lab=#net15}
N 4160 140 4160 160 { lab=#net15}
N 4160 -50 4160 10 { lab=#net15}
N 4160 100 4160 140 { lab=#net15}
N 4160 10 4160 40 { lab=#net15}
N 4080 -50 4080 160 { lab=#net16}
N 4020 60 4200 60 { lab=#net37}
N 4120 0 4130 0 { lab=#net37}
N 4120 0 4120 60 { lab=#net37}
N 4020 140 4130 140 { lab=#net42}
N 4190 140 4200 140 { lab=#net37}
N 4020 -20 4200 -20 { lab=VDD}
N 3150 270 3300 270 { lab=#net43}
N 3210 210 3220 210 { lab=#net43}
N 3220 210 3220 270 { lab=#net43}
N 3140 270 3150 270 { lab=#net43}
N 3150 190 3150 210 { lab=VDD}
N 3140 350 3150 350 { lab=GND}
N 3210 350 3300 350 { lab=#net44}
N 3180 250 3180 310 { lab=#net17}
N 3180 350 3180 370 { lab=#net17}
N 3180 160 3180 220 { lab=#net17}
N 3120 190 3300 190 { lab=VDD}
N 3260 170 3260 370 { lab=#net18}
N 3180 310 3180 350 { lab=#net17}
N 3180 220 3180 250 { lab=#net17}
N 3120 350 3140 350 { lab=GND}
N 3120 270 3140 270 { lab=#net43}
N 3260 160 3260 170 { lab=#net18}
N 3330 270 3480 270 { lab=#net43}
N 3390 210 3400 210 { lab=#net43}
N 3400 210 3400 270 { lab=#net43}
N 3320 270 3330 270 { lab=#net43}
N 3330 190 3330 210 { lab=VDD}
N 3320 350 3330 350 { lab=#net44}
N 3390 350 3480 350 { lab=#net45}
N 3360 250 3360 310 { lab=#net4}
N 3360 350 3360 370 { lab=#net4}
N 3360 160 3360 220 { lab=#net4}
N 3300 190 3480 190 { lab=VDD}
N 3440 170 3440 370 { lab=#net5}
N 3360 310 3360 350 { lab=#net4}
N 3360 220 3360 250 { lab=#net4}
N 3300 350 3320 350 { lab=#net44}
N 3300 270 3320 270 { lab=#net43}
N 3440 160 3440 170 { lab=#net5}
N 3690 270 3840 270 { lab=#net43}
N 3750 210 3760 210 { lab=#net43}
N 3760 210 3760 270 { lab=#net43}
N 3680 270 3690 270 { lab=#net43}
N 3690 190 3690 210 { lab=VDD}
N 3680 350 3690 350 { lab=#net46}
N 3750 350 3840 350 { lab=#net47}
N 3720 250 3720 310 { lab=#net10}
N 3720 350 3720 370 { lab=#net10}
N 3720 160 3720 220 { lab=#net10}
N 3660 190 3840 190 { lab=VDD}
N 3800 170 3800 370 { lab=#net11}
N 3720 310 3720 350 { lab=#net10}
N 3720 220 3720 250 { lab=#net10}
N 3660 350 3680 350 { lab=#net46}
N 3660 270 3680 270 { lab=#net43}
N 3800 160 3800 170 { lab=#net11}
N 3640 210 3650 210 { lab=VDD}
N 3650 190 3650 210 { lab=VDD}
N 3620 250 3620 310 { lab=#net8}
N 3620 350 3620 370 { lab=#net8}
N 3620 160 3620 220 { lab=#net8}
N 3620 310 3620 350 { lab=#net8}
N 3620 220 3620 250 { lab=#net8}
N 3540 160 3540 370 { lab=#net7}
N 3480 270 3660 270 { lab=#net43}
N 3580 210 3590 210 { lab=#net43}
N 3580 210 3580 270 { lab=#net43}
N 3480 350 3590 350 { lab=#net45}
N 3650 350 3660 350 { lab=#net46}
N 3480 190 3660 190 { lab=VDD}
N 4000 210 4010 210 { lab=VDD}
N 4010 190 4010 210 { lab=VDD}
N 3980 250 3980 310 { lab=#net12}
N 3980 350 3980 370 { lab=#net12}
N 3980 160 3980 220 { lab=#net12}
N 3980 310 3980 350 { lab=#net12}
N 3980 220 3980 250 { lab=#net12}
N 3900 160 3900 370 { lab=#net13}
N 3840 270 4020 270 { lab=#net43}
N 3940 210 3950 210 { lab=#net43}
N 3940 210 3940 270 { lab=#net43}
N 3840 350 3950 350 { lab=#net47}
N 4010 350 4020 350 { lab=#net48}
N 3840 190 4020 190 { lab=VDD}
N 4180 210 4190 210 { lab=VDD}
N 4190 190 4190 210 { lab=VDD}
N 4160 250 4160 310 { lab=#net15}
N 4160 350 4160 370 { lab=#net15}
N 4160 160 4160 220 { lab=#net15}
N 4160 310 4160 350 { lab=#net15}
N 4160 220 4160 250 { lab=#net15}
N 4080 160 4080 370 { lab=#net16}
N 4020 270 4200 270 { lab=#net43}
N 4120 210 4130 210 { lab=#net43}
N 4120 210 4120 270 { lab=#net43}
N 4020 350 4130 350 { lab=#net48}
N 4190 350 4200 350 { lab=#net43}
N 4020 190 4200 190 { lab=VDD}
N 3150 480 3300 480 { lab=#net49}
N 3210 420 3220 420 { lab=#net49}
N 3220 420 3220 480 { lab=#net49}
N 3140 480 3150 480 { lab=#net49}
N 3150 400 3150 420 { lab=VDD}
N 3140 560 3150 560 { lab=GND}
N 3210 560 3300 560 { lab=#net50}
N 3180 460 3180 520 { lab=#net17}
N 3180 560 3180 580 { lab=#net17}
N 3180 370 3180 430 { lab=#net17}
N 3120 400 3300 400 { lab=VDD}
N 3260 380 3260 580 { lab=#net18}
N 3180 520 3180 560 { lab=#net17}
N 3180 430 3180 460 { lab=#net17}
N 3120 560 3140 560 { lab=GND}
N 3120 480 3140 480 { lab=#net49}
N 3260 370 3260 380 { lab=#net18}
N 3690 480 3840 480 { lab=#net49}
N 3750 420 3760 420 { lab=#net49}
N 3760 420 3760 480 { lab=#net49}
N 3680 480 3690 480 { lab=#net49}
N 3690 400 3690 420 { lab=VDD}
N 3680 560 3690 560 { lab=#net51}
N 3750 560 3840 560 { lab=#net52}
N 3720 460 3720 520 { lab=#net10}
N 3720 560 3720 580 { lab=#net10}
N 3720 370 3720 430 { lab=#net10}
N 3660 400 3840 400 { lab=VDD}
N 3800 380 3800 580 { lab=#net11}
N 3720 520 3720 560 { lab=#net10}
N 3720 430 3720 460 { lab=#net10}
N 3660 560 3680 560 { lab=#net51}
N 3660 480 3680 480 { lab=#net49}
N 3800 370 3800 380 { lab=#net11}
N 3870 480 4020 480 { lab=#net49}
N 3930 420 3940 420 { lab=#net49}
N 3940 420 3940 480 { lab=#net49}
N 3860 480 3870 480 { lab=#net49}
N 3870 400 3870 420 { lab=VDD}
N 3860 560 3870 560 { lab=#net52}
N 3930 560 4020 560 { lab=#net53}
N 3900 460 3900 520 { lab=#net13}
N 3900 560 3900 580 { lab=#net13}
N 3900 370 3900 430 { lab=#net13}
N 3840 400 4020 400 { lab=VDD}
N 3980 380 3980 580 { lab=#net12}
N 3900 520 3900 560 { lab=#net13}
N 3900 430 3900 460 { lab=#net13}
N 3840 560 3860 560 { lab=#net52}
N 3840 480 3860 480 { lab=#net49}
N 3980 370 3980 380 { lab=#net12}
N 3640 420 3650 420 { lab=VDD}
N 3650 400 3650 420 { lab=VDD}
N 3620 460 3620 520 { lab=#net8}
N 3620 560 3620 580 { lab=#net8}
N 3620 370 3620 430 { lab=#net8}
N 3620 520 3620 560 { lab=#net8}
N 3620 430 3620 460 { lab=#net8}
N 3540 370 3540 580 { lab=#net7}
N 3480 480 3660 480 { lab=#net49}
N 3580 420 3590 420 { lab=#net49}
N 3580 420 3580 480 { lab=#net49}
N 3480 560 3590 560 { lab=#net54}
N 3650 560 3660 560 { lab=#net51}
N 3480 400 3660 400 { lab=VDD}
N 4180 420 4190 420 { lab=VDD}
N 4190 400 4190 420 { lab=VDD}
N 4160 460 4160 520 { lab=#net15}
N 4160 560 4160 580 { lab=#net15}
N 4160 370 4160 430 { lab=#net15}
N 4160 520 4160 560 { lab=#net15}
N 4160 430 4160 460 { lab=#net15}
N 4080 370 4080 580 { lab=#net16}
N 4020 480 4200 480 { lab=#net49}
N 4120 420 4130 420 { lab=#net49}
N 4120 420 4120 480 { lab=#net49}
N 4020 560 4130 560 { lab=#net53}
N 4190 560 4200 560 { lab=#net49}
N 4020 400 4200 400 { lab=VDD}
N 3460 420 3470 420 { lab=VDD}
N 3470 400 3470 420 { lab=VDD}
N 3440 460 3440 520 { lab=#net5}
N 3440 560 3440 580 { lab=#net5}
N 3440 370 3440 430 { lab=#net5}
N 3440 520 3440 560 { lab=#net5}
N 3440 430 3440 460 { lab=#net5}
N 3360 370 3360 580 { lab=#net4}
N 3300 480 3480 480 { lab=#net49}
N 3400 420 3410 420 { lab=#net49}
N 3400 420 3400 480 { lab=#net49}
N 3300 560 3410 560 { lab=#net50}
N 3470 560 3480 560 { lab=#net54}
N 3300 400 3480 400 { lab=VDD}
N 3150 690 3300 690 { lab=#net55}
N 3210 630 3220 630 { lab=#net55}
N 3220 630 3220 690 { lab=#net55}
N 3140 690 3150 690 { lab=#net55}
N 3150 610 3150 630 { lab=VDD}
N 3140 770 3150 770 { lab=GND}
N 3210 770 3300 770 { lab=#net56}
N 3180 670 3180 730 { lab=#net17}
N 3180 770 3180 790 { lab=#net17}
N 3180 580 3180 640 { lab=#net17}
N 3120 610 3300 610 { lab=VDD}
N 3260 590 3260 790 { lab=#net18}
N 3180 730 3180 770 { lab=#net17}
N 3180 640 3180 670 { lab=#net17}
N 3120 770 3140 770 { lab=GND}
N 3120 690 3140 690 { lab=#net55}
N 3260 580 3260 590 { lab=#net18}
N 3460 630 3470 630 { lab=VDD}
N 3470 610 3470 630 { lab=VDD}
N 3440 670 3440 730 { lab=#net5}
N 3440 770 3440 790 { lab=#net5}
N 3440 580 3440 640 { lab=#net5}
N 3440 730 3440 770 { lab=#net5}
N 3440 640 3440 670 { lab=#net5}
N 3360 580 3360 790 { lab=#net4}
N 3300 690 3480 690 { lab=#net55}
N 3400 630 3410 630 { lab=#net55}
N 3400 630 3400 690 { lab=#net55}
N 3300 770 3410 770 { lab=#net56}
N 3470 770 3480 770 { lab=#net57}
N 3300 610 3480 610 { lab=VDD}
N 3640 630 3650 630 { lab=VDD}
N 3650 610 3650 630 { lab=VDD}
N 3620 670 3620 730 { lab=#net8}
N 3620 770 3620 790 { lab=#net8}
N 3620 580 3620 640 { lab=#net8}
N 3620 730 3620 770 { lab=#net8}
N 3620 640 3620 670 { lab=#net8}
N 3540 580 3540 790 { lab=#net7}
N 3480 690 3660 690 { lab=#net55}
N 3580 630 3590 630 { lab=#net55}
N 3580 630 3580 690 { lab=#net55}
N 3480 770 3590 770 { lab=#net57}
N 3650 770 3660 770 { lab=#net58}
N 3480 610 3660 610 { lab=VDD}
N 3820 630 3830 630 { lab=VDD}
N 3830 610 3830 630 { lab=VDD}
N 3800 670 3800 730 { lab=#net11}
N 3800 770 3800 790 { lab=#net11}
N 3800 580 3800 640 { lab=#net11}
N 3800 730 3800 770 { lab=#net11}
N 3800 640 3800 670 { lab=#net11}
N 3720 580 3720 790 { lab=#net10}
N 3660 690 3840 690 { lab=#net55}
N 3760 630 3770 630 { lab=#net55}
N 3760 630 3760 690 { lab=#net55}
N 3660 770 3770 770 { lab=#net58}
N 3830 770 3840 770 { lab=#net59}
N 3660 610 3840 610 { lab=VDD}
N 4000 630 4010 630 { lab=VDD}
N 4010 610 4010 630 { lab=VDD}
N 3980 670 3980 730 { lab=#net12}
N 3980 770 3980 790 { lab=#net12}
N 3980 580 3980 640 { lab=#net12}
N 3980 730 3980 770 { lab=#net12}
N 3980 640 3980 670 { lab=#net12}
N 3900 580 3900 790 { lab=#net13}
N 3840 690 4020 690 { lab=#net55}
N 3940 630 3950 630 { lab=#net55}
N 3940 630 3940 690 { lab=#net55}
N 3840 770 3950 770 { lab=#net59}
N 4010 770 4020 770 { lab=#net60}
N 3840 610 4020 610 { lab=VDD}
N 4180 630 4190 630 { lab=VDD}
N 4190 610 4190 630 { lab=VDD}
N 4160 670 4160 730 { lab=#net15}
N 4160 770 4160 790 { lab=#net15}
N 4160 580 4160 640 { lab=#net15}
N 4160 730 4160 770 { lab=#net15}
N 4160 640 4160 670 { lab=#net15}
N 4080 580 4080 790 { lab=#net16}
N 4020 690 4200 690 { lab=#net55}
N 4120 630 4130 630 { lab=#net55}
N 4120 630 4120 690 { lab=#net55}
N 4020 770 4130 770 { lab=#net60}
N 4190 770 4200 770 { lab=#net55}
N 4020 610 4200 610 { lab=VDD}
N 3150 900 3300 900 { lab=#net61}
N 3210 840 3220 840 { lab=#net61}
N 3220 840 3220 900 { lab=#net61}
N 3140 900 3150 900 { lab=#net61}
N 3150 820 3150 840 { lab=VDD}
N 3140 980 3150 980 { lab=GND}
N 3210 980 3300 980 { lab=#net62}
N 3180 880 3180 940 { lab=#net17}
N 3180 980 3180 1000 { lab=#net17}
N 3180 790 3180 850 { lab=#net17}
N 3120 820 3300 820 { lab=VDD}
N 3260 800 3260 1000 { lab=#net18}
N 3180 940 3180 980 { lab=#net17}
N 3180 850 3180 880 { lab=#net17}
N 3120 980 3140 980 { lab=GND}
N 3120 900 3140 900 { lab=#net61}
N 3260 790 3260 800 { lab=#net18}
N 3460 840 3470 840 { lab=VDD}
N 3470 820 3470 840 { lab=VDD}
N 3440 880 3440 940 { lab=#net5}
N 3440 980 3440 1000 { lab=#net5}
N 3440 790 3440 850 { lab=#net5}
N 3440 940 3440 980 { lab=#net5}
N 3440 850 3440 880 { lab=#net5}
N 3360 790 3360 1000 { lab=#net4}
N 3300 900 3480 900 { lab=#net61}
N 3400 840 3410 840 { lab=#net61}
N 3400 840 3400 900 { lab=#net61}
N 3300 980 3410 980 { lab=#net62}
N 3470 980 3480 980 { lab=#net63}
N 3300 820 3480 820 { lab=VDD}
N 3640 840 3650 840 { lab=VDD}
N 3650 820 3650 840 { lab=VDD}
N 3620 880 3620 940 { lab=#net8}
N 3620 980 3620 1000 { lab=#net8}
N 3620 790 3620 850 { lab=#net8}
N 3620 940 3620 980 { lab=#net8}
N 3620 850 3620 880 { lab=#net8}
N 3540 790 3540 1000 { lab=#net7}
N 3480 900 3660 900 { lab=#net61}
N 3580 840 3590 840 { lab=#net61}
N 3580 840 3580 900 { lab=#net61}
N 3480 980 3590 980 { lab=#net63}
N 3650 980 3660 980 { lab=#net64}
N 3480 820 3660 820 { lab=VDD}
N 3820 840 3830 840 { lab=VDD}
N 3830 820 3830 840 { lab=VDD}
N 3800 880 3800 940 { lab=#net11}
N 3800 980 3800 1000 { lab=#net11}
N 3800 790 3800 850 { lab=#net11}
N 3800 940 3800 980 { lab=#net11}
N 3800 850 3800 880 { lab=#net11}
N 3720 790 3720 1000 { lab=#net10}
N 3660 900 3840 900 { lab=#net61}
N 3760 840 3770 840 { lab=#net61}
N 3760 840 3760 900 { lab=#net61}
N 3660 980 3770 980 { lab=#net64}
N 3830 980 3840 980 { lab=#net65}
N 3660 820 3840 820 { lab=VDD}
N 3870 900 4020 900 { lab=#net61}
N 3930 840 3940 840 { lab=#net61}
N 3940 840 3940 900 { lab=#net61}
N 3860 900 3870 900 { lab=#net61}
N 3870 820 3870 840 { lab=VDD}
N 3860 980 3870 980 { lab=#net65}
N 3930 980 4020 980 { lab=#net66}
N 3900 880 3900 940 { lab=#net13}
N 3900 980 3900 1000 { lab=#net13}
N 3900 790 3900 850 { lab=#net13}
N 3840 820 4020 820 { lab=VDD}
N 3980 800 3980 1000 { lab=#net12}
N 3900 940 3900 980 { lab=#net13}
N 3900 850 3900 880 { lab=#net13}
N 3840 980 3860 980 { lab=#net65}
N 3840 900 3860 900 { lab=#net61}
N 3980 790 3980 800 { lab=#net12}
N 4050 900 4200 900 { lab=#net61}
N 4110 840 4120 840 { lab=#net61}
N 4120 840 4120 900 { lab=#net61}
N 4040 900 4050 900 { lab=#net61}
N 4050 820 4050 840 { lab=VDD}
N 4040 980 4050 980 { lab=#net66}
N 4110 980 4200 980 { lab=#net61}
N 4080 880 4080 940 { lab=#net16}
N 4080 980 4080 1000 { lab=#net16}
N 4080 790 4080 850 { lab=#net16}
N 4020 820 4200 820 { lab=VDD}
N 4160 800 4160 1000 { lab=#net15}
N 4080 940 4080 980 { lab=#net16}
N 4080 850 4080 880 { lab=#net16}
N 4020 980 4040 980 { lab=#net66}
N 4020 900 4040 900 { lab=#net61}
N 4160 790 4160 800 { lab=#net15}
N 3150 1110 3300 1110 { lab=#net67}
N 3210 1050 3220 1050 { lab=#net67}
N 3220 1050 3220 1110 { lab=#net67}
N 3140 1110 3150 1110 { lab=#net67}
N 3150 1030 3150 1050 { lab=VDD}
N 3140 1190 3150 1190 { lab=GND}
N 3210 1190 3300 1190 { lab=#net68}
N 3180 1090 3180 1150 { lab=#net17}
N 3180 1190 3180 1210 { lab=#net17}
N 3180 1000 3180 1060 { lab=#net17}
N 3120 1030 3300 1030 { lab=VDD}
N 3260 1010 3260 1210 { lab=#net18}
N 3180 1150 3180 1190 { lab=#net17}
N 3180 1060 3180 1090 { lab=#net17}
N 3120 1190 3140 1190 { lab=GND}
N 3120 1110 3140 1110 { lab=#net67}
N 3260 1000 3260 1010 { lab=#net18}
N 3460 1050 3470 1050 { lab=VDD}
N 3470 1030 3470 1050 { lab=VDD}
N 3440 1090 3440 1150 { lab=#net5}
N 3440 1190 3440 1210 { lab=#net5}
N 3440 1000 3440 1060 { lab=#net5}
N 3440 1150 3440 1190 { lab=#net5}
N 3440 1060 3440 1090 { lab=#net5}
N 3360 1000 3360 1210 { lab=#net4}
N 3300 1110 3480 1110 { lab=#net67}
N 3400 1050 3410 1050 { lab=#net67}
N 3400 1050 3400 1110 { lab=#net67}
N 3300 1190 3410 1190 { lab=#net68}
N 3470 1190 3480 1190 { lab=#net69}
N 3300 1030 3480 1030 { lab=VDD}
N 3510 1110 3660 1110 { lab=#net67}
N 3570 1050 3580 1050 { lab=#net67}
N 3580 1050 3580 1110 { lab=#net67}
N 3500 1110 3510 1110 { lab=#net67}
N 3510 1030 3510 1050 { lab=VDD}
N 3500 1190 3510 1190 { lab=#net69}
N 3570 1190 3660 1190 { lab=#net70}
N 3540 1090 3540 1150 { lab=#net7}
N 3540 1190 3540 1210 { lab=#net7}
N 3540 1000 3540 1060 { lab=#net7}
N 3480 1030 3660 1030 { lab=VDD}
N 3620 1010 3620 1210 { lab=#net8}
N 3540 1150 3540 1190 { lab=#net7}
N 3540 1060 3540 1090 { lab=#net7}
N 3480 1190 3500 1190 { lab=#net69}
N 3480 1110 3500 1110 { lab=#net67}
N 3620 1000 3620 1010 { lab=#net8}
N 3690 1110 3840 1110 { lab=#net67}
N 3750 1050 3760 1050 { lab=#net67}
N 3760 1050 3760 1110 { lab=#net67}
N 3680 1110 3690 1110 { lab=#net67}
N 3690 1030 3690 1050 { lab=VDD}
N 3680 1190 3690 1190 { lab=#net70}
N 3750 1190 3840 1190 { lab=#net71}
N 3720 1090 3720 1150 { lab=#net10}
N 3720 1190 3720 1210 { lab=#net10}
N 3720 1000 3720 1060 { lab=#net10}
N 3660 1030 3840 1030 { lab=VDD}
N 3800 1010 3800 1210 { lab=#net11}
N 3720 1150 3720 1190 { lab=#net10}
N 3720 1060 3720 1090 { lab=#net10}
N 3660 1190 3680 1190 { lab=#net70}
N 3660 1110 3680 1110 { lab=#net67}
N 3800 1000 3800 1010 { lab=#net11}
N 3870 1110 4020 1110 { lab=#net67}
N 3930 1050 3940 1050 { lab=#net67}
N 3940 1050 3940 1110 { lab=#net67}
N 3860 1110 3870 1110 { lab=#net67}
N 3870 1030 3870 1050 { lab=VDD}
N 3860 1190 3870 1190 { lab=#net71}
N 3930 1190 4020 1190 { lab=#net72}
N 3900 1090 3900 1150 { lab=#net13}
N 3900 1190 3900 1210 { lab=#net13}
N 3900 1000 3900 1060 { lab=#net13}
N 3840 1030 4020 1030 { lab=VDD}
N 3980 1010 3980 1210 { lab=#net12}
N 3900 1150 3900 1190 { lab=#net13}
N 3900 1060 3900 1090 { lab=#net13}
N 3840 1190 3860 1190 { lab=#net71}
N 3840 1110 3860 1110 { lab=#net67}
N 3980 1000 3980 1010 { lab=#net12}
N 4050 1110 4200 1110 { lab=#net67}
N 4110 1050 4120 1050 { lab=#net67}
N 4120 1050 4120 1110 { lab=#net67}
N 4040 1110 4050 1110 { lab=#net67}
N 4050 1030 4050 1050 { lab=VDD}
N 4040 1190 4050 1190 { lab=#net72}
N 4110 1190 4200 1190 { lab=#net67}
N 4080 1090 4080 1150 { lab=#net16}
N 4080 1190 4080 1210 { lab=#net16}
N 4080 1000 4080 1060 { lab=#net16}
N 4020 1030 4200 1030 { lab=VDD}
N 4160 1010 4160 1210 { lab=#net15}
N 4080 1150 4080 1190 { lab=#net16}
N 4080 1060 4080 1090 { lab=#net16}
N 4020 1190 4040 1190 { lab=#net72}
N 4020 1110 4040 1110 { lab=#net67}
N 4160 1000 4160 1010 { lab=#net15}
N 3280 1260 3290 1260 { lab=VDD}
N 3290 1240 3290 1260 { lab=VDD}
N 3260 1300 3260 1360 { lab=#net18}
N 3260 1400 3260 1420 { lab=#net18}
N 3260 1210 3260 1270 { lab=#net18}
N 3260 1360 3260 1400 { lab=#net18}
N 3260 1270 3260 1300 { lab=#net18}
N 3180 1210 3180 1420 { lab=#net17}
N 3120 1320 3300 1320 { lab=#net73}
N 3220 1260 3230 1260 { lab=#net73}
N 3220 1260 3220 1320 { lab=#net73}
N 3120 1400 3230 1400 { lab=GND}
N 3290 1400 3300 1400 { lab=#net74}
N 3120 1240 3300 1240 { lab=VDD}
N 3460 1260 3470 1260 { lab=VDD}
N 3470 1240 3470 1260 { lab=VDD}
N 3440 1300 3440 1360 { lab=#net5}
N 3440 1400 3440 1420 { lab=#net5}
N 3440 1210 3440 1270 { lab=#net5}
N 3440 1360 3440 1400 { lab=#net5}
N 3440 1270 3440 1300 { lab=#net5}
N 3360 1210 3360 1420 { lab=#net4}
N 3300 1320 3480 1320 { lab=#net73}
N 3400 1260 3410 1260 { lab=#net73}
N 3400 1260 3400 1320 { lab=#net73}
N 3300 1400 3410 1400 { lab=#net74}
N 3470 1400 3480 1400 { lab=#net75}
N 3300 1240 3480 1240 { lab=VDD}
N 3510 1320 3660 1320 { lab=#net73}
N 3570 1260 3580 1260 { lab=#net73}
N 3580 1260 3580 1320 { lab=#net73}
N 3500 1320 3510 1320 { lab=#net73}
N 3510 1240 3510 1260 { lab=VDD}
N 3500 1400 3510 1400 { lab=#net75}
N 3570 1400 3660 1400 { lab=#net76}
N 3540 1300 3540 1360 { lab=#net7}
N 3540 1400 3540 1420 { lab=#net7}
N 3540 1210 3540 1270 { lab=#net7}
N 3480 1240 3660 1240 { lab=VDD}
N 3620 1220 3620 1420 { lab=#net8}
N 3540 1360 3540 1400 { lab=#net7}
N 3540 1270 3540 1300 { lab=#net7}
N 3480 1400 3500 1400 { lab=#net75}
N 3480 1320 3500 1320 { lab=#net73}
N 3620 1210 3620 1220 { lab=#net8}
N 3690 1320 3840 1320 { lab=#net73}
N 3750 1260 3760 1260 { lab=#net73}
N 3760 1260 3760 1320 { lab=#net73}
N 3680 1320 3690 1320 { lab=#net73}
N 3690 1240 3690 1260 { lab=VDD}
N 3680 1400 3690 1400 { lab=#net76}
N 3750 1400 3840 1400 { lab=#net77}
N 3720 1300 3720 1360 { lab=#net10}
N 3720 1400 3720 1420 { lab=#net10}
N 3720 1210 3720 1270 { lab=#net10}
N 3660 1240 3840 1240 { lab=VDD}
N 3800 1220 3800 1420 { lab=#net11}
N 3720 1360 3720 1400 { lab=#net10}
N 3720 1270 3720 1300 { lab=#net10}
N 3660 1400 3680 1400 { lab=#net76}
N 3660 1320 3680 1320 { lab=#net73}
N 3800 1210 3800 1220 { lab=#net11}
N 3870 1320 4020 1320 { lab=#net73}
N 3930 1260 3940 1260 { lab=#net73}
N 3940 1260 3940 1320 { lab=#net73}
N 3860 1320 3870 1320 { lab=#net73}
N 3870 1240 3870 1260 { lab=VDD}
N 3860 1400 3870 1400 { lab=#net77}
N 3930 1400 4020 1400 { lab=#net78}
N 3900 1300 3900 1360 { lab=#net13}
N 3900 1400 3900 1420 { lab=#net13}
N 3900 1210 3900 1270 { lab=#net13}
N 3840 1240 4020 1240 { lab=VDD}
N 3980 1220 3980 1420 { lab=#net12}
N 3900 1360 3900 1400 { lab=#net13}
N 3900 1270 3900 1300 { lab=#net13}
N 3840 1400 3860 1400 { lab=#net77}
N 3840 1320 3860 1320 { lab=#net73}
N 3980 1210 3980 1220 { lab=#net12}
N 4050 1320 4200 1320 { lab=#net73}
N 4110 1260 4120 1260 { lab=#net73}
N 4120 1260 4120 1320 { lab=#net73}
N 4040 1320 4050 1320 { lab=#net73}
N 4050 1240 4050 1260 { lab=VDD}
N 4040 1400 4050 1400 { lab=#net78}
N 4110 1400 4200 1400 { lab=#net73}
N 4080 1300 4080 1360 { lab=#net16}
N 4080 1400 4080 1420 { lab=#net16}
N 4080 1210 4080 1270 { lab=#net16}
N 4020 1240 4200 1240 { lab=VDD}
N 4160 1220 4160 1420 { lab=#net15}
N 4080 1360 4080 1400 { lab=#net16}
N 4080 1270 4080 1300 { lab=#net16}
N 4020 1400 4040 1400 { lab=#net78}
N 4020 1320 4040 1320 { lab=#net73}
N 4160 1210 4160 1220 { lab=#net15}
N 3280 1470 3290 1470 { lab=VDD}
N 3290 1450 3290 1470 { lab=VDD}
N 3260 1510 3260 1570 { lab=#net18}
N 3260 1610 3260 1630 { lab=#net18}
N 3260 1420 3260 1480 { lab=#net18}
N 3260 1570 3260 1610 { lab=#net18}
N 3260 1480 3260 1510 { lab=#net18}
N 3180 1420 3180 1630 { lab=#net17}
N 3120 1530 3300 1530 { lab=#net79}
N 3220 1470 3230 1470 { lab=#net79}
N 3220 1470 3220 1530 { lab=#net79}
N 3120 1610 3230 1610 { lab=GND}
N 3290 1610 3300 1610 { lab=#net80}
N 3120 1450 3300 1450 { lab=VDD}
N 3460 1470 3470 1470 { lab=VDD}
N 3470 1450 3470 1470 { lab=VDD}
N 3440 1510 3440 1570 { lab=#net5}
N 3440 1610 3440 1630 { lab=#net5}
N 3440 1420 3440 1480 { lab=#net5}
N 3440 1570 3440 1610 { lab=#net5}
N 3440 1480 3440 1510 { lab=#net5}
N 3360 1420 3360 1630 { lab=#net4}
N 3300 1530 3480 1530 { lab=#net79}
N 3400 1470 3410 1470 { lab=#net79}
N 3400 1470 3400 1530 { lab=#net79}
N 3300 1610 3410 1610 { lab=#net80}
N 3470 1610 3480 1610 { lab=#net81}
N 3300 1450 3480 1450 { lab=VDD}
N 3640 1470 3650 1470 { lab=VDD}
N 3650 1450 3650 1470 { lab=VDD}
N 3620 1510 3620 1570 { lab=#net8}
N 3620 1610 3620 1630 { lab=#net8}
N 3620 1420 3620 1480 { lab=#net8}
N 3620 1570 3620 1610 { lab=#net8}
N 3620 1480 3620 1510 { lab=#net8}
N 3540 1420 3540 1630 { lab=#net7}
N 3480 1530 3660 1530 { lab=#net79}
N 3580 1470 3590 1470 { lab=#net79}
N 3580 1470 3580 1530 { lab=#net79}
N 3480 1610 3590 1610 { lab=#net81}
N 3650 1610 3660 1610 { lab=#net82}
N 3480 1450 3660 1450 { lab=VDD}
N 3820 1470 3830 1470 { lab=VDD}
N 3830 1450 3830 1470 { lab=VDD}
N 3800 1510 3800 1570 { lab=#net11}
N 3800 1610 3800 1630 { lab=#net11}
N 3800 1420 3800 1480 { lab=#net11}
N 3800 1570 3800 1610 { lab=#net11}
N 3800 1480 3800 1510 { lab=#net11}
N 3720 1420 3720 1630 { lab=#net10}
N 3660 1530 3840 1530 { lab=#net79}
N 3760 1470 3770 1470 { lab=#net79}
N 3760 1470 3760 1530 { lab=#net79}
N 3660 1610 3770 1610 { lab=#net82}
N 3830 1610 3840 1610 { lab=#net83}
N 3660 1450 3840 1450 { lab=VDD}
N 3870 1530 4020 1530 { lab=#net79}
N 3930 1470 3940 1470 { lab=#net79}
N 3940 1470 3940 1530 { lab=#net79}
N 3860 1530 3870 1530 { lab=#net79}
N 3870 1450 3870 1470 { lab=VDD}
N 3860 1610 3870 1610 { lab=#net83}
N 3930 1610 4020 1610 { lab=#net84}
N 3900 1510 3900 1570 { lab=#net13}
N 3900 1610 3900 1630 { lab=#net13}
N 3900 1420 3900 1480 { lab=#net13}
N 3840 1450 4020 1450 { lab=VDD}
N 3980 1430 3980 1630 { lab=#net12}
N 3900 1570 3900 1610 { lab=#net13}
N 3900 1480 3900 1510 { lab=#net13}
N 3840 1610 3860 1610 { lab=#net83}
N 3840 1530 3860 1530 { lab=#net79}
N 3980 1420 3980 1430 { lab=#net12}
N 4050 1530 4200 1530 { lab=#net79}
N 4110 1470 4120 1470 { lab=#net79}
N 4120 1470 4120 1530 { lab=#net79}
N 4040 1530 4050 1530 { lab=#net79}
N 4050 1450 4050 1470 { lab=VDD}
N 4040 1610 4050 1610 { lab=#net84}
N 4110 1610 4200 1610 { lab=#net79}
N 4080 1510 4080 1570 { lab=#net16}
N 4080 1610 4080 1630 { lab=#net16}
N 4080 1420 4080 1480 { lab=#net16}
N 4020 1450 4200 1450 { lab=VDD}
N 4160 1430 4160 1630 { lab=#net15}
N 4080 1570 4080 1610 { lab=#net16}
N 4080 1480 4080 1510 { lab=#net16}
N 4020 1610 4040 1610 { lab=#net84}
N 4020 1530 4040 1530 { lab=#net79}
N 4160 1420 4160 1430 { lab=#net15}
N 3280 1680 3290 1680 { lab=VDD}
N 3290 1660 3290 1680 { lab=VDD}
N 3260 1720 3260 1780 { lab=#net18}
N 3260 1820 3260 1840 { lab=#net18}
N 3260 1630 3260 1690 { lab=#net18}
N 3260 1780 3260 1820 { lab=#net18}
N 3260 1690 3260 1720 { lab=#net18}
N 3180 1630 3180 1840 { lab=#net17}
N 3120 1740 3300 1740 { lab=#net85}
N 3220 1680 3230 1680 { lab=#net85}
N 3220 1680 3220 1740 { lab=#net85}
N 3120 1820 3230 1820 { lab=GND}
N 3290 1820 3300 1820 { lab=#net86}
N 3120 1660 3300 1660 { lab=VDD}
N 3460 1680 3470 1680 { lab=VDD}
N 3470 1660 3470 1680 { lab=VDD}
N 3440 1720 3440 1780 { lab=#net5}
N 3440 1820 3440 1840 { lab=#net5}
N 3440 1630 3440 1690 { lab=#net5}
N 3440 1780 3440 1820 { lab=#net5}
N 3440 1690 3440 1720 { lab=#net5}
N 3360 1630 3360 1840 { lab=#net4}
N 3300 1740 3480 1740 { lab=#net85}
N 3400 1680 3410 1680 { lab=#net85}
N 3400 1680 3400 1740 { lab=#net85}
N 3300 1820 3410 1820 { lab=#net86}
N 3470 1820 3480 1820 { lab=#net87}
N 3300 1660 3480 1660 { lab=VDD}
N 3640 1680 3650 1680 { lab=VDD}
N 3650 1660 3650 1680 { lab=VDD}
N 3620 1720 3620 1780 { lab=#net8}
N 3620 1820 3620 1840 { lab=#net8}
N 3620 1630 3620 1690 { lab=#net8}
N 3620 1780 3620 1820 { lab=#net8}
N 3620 1690 3620 1720 { lab=#net8}
N 3540 1630 3540 1840 { lab=#net7}
N 3480 1740 3660 1740 { lab=#net85}
N 3580 1680 3590 1680 { lab=#net85}
N 3580 1680 3580 1740 { lab=#net85}
N 3480 1820 3590 1820 { lab=#net87}
N 3650 1820 3660 1820 { lab=#net88}
N 3480 1660 3660 1660 { lab=VDD}
N 3820 1680 3830 1680 { lab=VDD}
N 3830 1660 3830 1680 { lab=VDD}
N 3800 1720 3800 1780 { lab=#net11}
N 3800 1820 3800 1840 { lab=#net11}
N 3800 1630 3800 1690 { lab=#net11}
N 3800 1780 3800 1820 { lab=#net11}
N 3800 1690 3800 1720 { lab=#net11}
N 3720 1630 3720 1840 { lab=#net10}
N 3660 1740 3840 1740 { lab=#net85}
N 3760 1680 3770 1680 { lab=#net85}
N 3760 1680 3760 1740 { lab=#net85}
N 3660 1820 3770 1820 { lab=#net88}
N 3830 1820 3840 1820 { lab=#net89}
N 3660 1660 3840 1660 { lab=VDD}
N 4000 1680 4010 1680 { lab=VDD}
N 4010 1660 4010 1680 { lab=VDD}
N 3980 1720 3980 1780 { lab=#net12}
N 3980 1820 3980 1840 { lab=#net12}
N 3980 1630 3980 1690 { lab=#net12}
N 3980 1780 3980 1820 { lab=#net12}
N 3980 1690 3980 1720 { lab=#net12}
N 3900 1630 3900 1840 { lab=#net13}
N 3840 1740 4020 1740 { lab=#net85}
N 3940 1680 3950 1680 { lab=#net85}
N 3940 1680 3940 1740 { lab=#net85}
N 3840 1820 3950 1820 { lab=#net89}
N 4010 1820 4020 1820 { lab=#net90}
N 3840 1660 4020 1660 { lab=VDD}
N 4180 1680 4190 1680 { lab=VDD}
N 4190 1660 4190 1680 { lab=VDD}
N 4160 1720 4160 1780 { lab=#net15}
N 4160 1820 4160 1840 { lab=#net15}
N 4160 1630 4160 1690 { lab=#net15}
N 4160 1780 4160 1820 { lab=#net15}
N 4160 1690 4160 1720 { lab=#net15}
N 4080 1630 4080 1840 { lab=#net16}
N 4020 1740 4200 1740 { lab=#net85}
N 4120 1680 4130 1680 { lab=#net85}
N 4120 1680 4120 1740 { lab=#net85}
N 4020 1820 4130 1820 { lab=#net90}
N 4190 1820 4200 1820 { lab=#net85}
N 4020 1660 4200 1660 { lab=VDD}
N 3280 1890 3290 1890 { lab=VDD}
N 3290 1870 3290 1890 { lab=VDD}
N 3260 1930 3260 1990 { lab=#net18}
N 3260 2030 3260 2050 { lab=#net18}
N 3260 1840 3260 1900 { lab=#net18}
N 3260 1990 3260 2030 { lab=#net18}
N 3260 1900 3260 1930 { lab=#net18}
N 3180 1840 3180 2050 { lab=#net17}
N 3120 1950 3300 1950 { lab=#net91}
N 3220 1890 3230 1890 { lab=#net91}
N 3220 1890 3220 1950 { lab=#net91}
N 3120 2030 3230 2030 { lab=GND}
N 3290 2030 3300 2030 { lab=#net92}
N 3120 1870 3300 1870 { lab=VDD}
N 3460 1890 3470 1890 { lab=VDD}
N 3470 1870 3470 1890 { lab=VDD}
N 3440 1930 3440 1990 { lab=#net5}
N 3440 2030 3440 2050 { lab=#net5}
N 3440 1840 3440 1900 { lab=#net5}
N 3440 1990 3440 2030 { lab=#net5}
N 3440 1900 3440 1930 { lab=#net5}
N 3360 1840 3360 2050 { lab=#net4}
N 3300 1950 3480 1950 { lab=#net91}
N 3400 1890 3410 1890 { lab=#net91}
N 3400 1890 3400 1950 { lab=#net91}
N 3300 2030 3410 2030 { lab=#net92}
N 3470 2030 3480 2030 { lab=#net93}
N 3300 1870 3480 1870 { lab=VDD}
N 3640 1890 3650 1890 { lab=VDD}
N 3650 1870 3650 1890 { lab=VDD}
N 3620 1930 3620 1990 { lab=#net8}
N 3620 2030 3620 2050 { lab=#net8}
N 3620 1840 3620 1900 { lab=#net8}
N 3620 1990 3620 2030 { lab=#net8}
N 3620 1900 3620 1930 { lab=#net8}
N 3540 1840 3540 2050 { lab=#net7}
N 3480 1950 3660 1950 { lab=#net91}
N 3580 1890 3590 1890 { lab=#net91}
N 3580 1890 3580 1950 { lab=#net91}
N 3480 2030 3590 2030 { lab=#net93}
N 3650 2030 3660 2030 { lab=#net94}
N 3480 1870 3660 1870 { lab=VDD}
N 3690 1950 3840 1950 { lab=#net91}
N 3750 1890 3760 1890 { lab=#net91}
N 3760 1890 3760 1950 { lab=#net91}
N 3680 1950 3690 1950 { lab=#net91}
N 3690 1870 3690 1890 { lab=VDD}
N 3680 2030 3690 2030 { lab=#net94}
N 3750 2030 3840 2030 { lab=#net95}
N 3720 1930 3720 1990 { lab=#net10}
N 3720 2030 3720 2050 { lab=#net10}
N 3720 1840 3720 1900 { lab=#net10}
N 3660 1870 3840 1870 { lab=VDD}
N 3800 1850 3800 2050 { lab=#net11}
N 3720 1990 3720 2030 { lab=#net10}
N 3720 1900 3720 1930 { lab=#net10}
N 3660 2030 3680 2030 { lab=#net94}
N 3660 1950 3680 1950 { lab=#net91}
N 3800 1840 3800 1850 { lab=#net11}
N 3870 1950 4020 1950 { lab=#net91}
N 3930 1890 3940 1890 { lab=#net91}
N 3940 1890 3940 1950 { lab=#net91}
N 3860 1950 3870 1950 { lab=#net91}
N 3870 1870 3870 1890 { lab=VDD}
N 3860 2030 3870 2030 { lab=#net95}
N 3930 2030 4020 2030 { lab=#net96}
N 3900 1930 3900 1990 { lab=#net13}
N 3900 2030 3900 2050 { lab=#net13}
N 3900 1840 3900 1900 { lab=#net13}
N 3840 1870 4020 1870 { lab=VDD}
N 3980 1850 3980 2050 { lab=#net12}
N 3900 1990 3900 2030 { lab=#net13}
N 3900 1900 3900 1930 { lab=#net13}
N 3840 2030 3860 2030 { lab=#net95}
N 3840 1950 3860 1950 { lab=#net91}
N 3980 1840 3980 1850 { lab=#net12}
N 4180 1890 4190 1890 { lab=VDD}
N 4190 1870 4190 1890 { lab=VDD}
N 4160 1930 4160 1990 { lab=#net15}
N 4160 2030 4160 2050 { lab=#net15}
N 4160 1840 4160 1900 { lab=#net15}
N 4160 1990 4160 2030 { lab=#net15}
N 4160 1900 4160 1930 { lab=#net15}
N 4080 1840 4080 2050 { lab=#net16}
N 4020 1950 4200 1950 { lab=#net91}
N 4120 1890 4130 1890 { lab=#net91}
N 4120 1890 4120 1950 { lab=#net91}
N 4020 2030 4130 2030 { lab=#net96}
N 4190 2030 4200 2030 { lab=#net91}
N 4020 1870 4200 1870 { lab=VDD}
N 3280 2100 3290 2100 { lab=VDD}
N 3290 2080 3290 2100 { lab=VDD}
N 3260 2140 3260 2200 { lab=#net18}
N 3260 2240 3260 2260 { lab=#net18}
N 3260 2050 3260 2110 { lab=#net18}
N 3260 2200 3260 2240 { lab=#net18}
N 3260 2110 3260 2140 { lab=#net18}
N 3180 2050 3180 2260 { lab=#net17}
N 3120 2160 3300 2160 { lab=#net97}
N 3220 2100 3230 2100 { lab=#net97}
N 3220 2100 3220 2160 { lab=#net97}
N 3120 2240 3230 2240 { lab=GND}
N 3290 2240 3300 2240 { lab=#net98}
N 3120 2080 3300 2080 { lab=VDD}
N 3330 2160 3480 2160 { lab=#net97}
N 3390 2100 3400 2100 { lab=#net97}
N 3400 2100 3400 2160 { lab=#net97}
N 3320 2160 3330 2160 { lab=#net97}
N 3330 2080 3330 2100 { lab=VDD}
N 3320 2240 3330 2240 { lab=#net98}
N 3390 2240 3480 2240 { lab=#net99}
N 3360 2140 3360 2200 { lab=#net4}
N 3360 2240 3360 2260 { lab=#net4}
N 3360 2050 3360 2110 { lab=#net4}
N 3300 2080 3480 2080 { lab=VDD}
N 3440 2060 3440 2260 { lab=#net5}
N 3360 2200 3360 2240 { lab=#net4}
N 3360 2110 3360 2140 { lab=#net4}
N 3300 2240 3320 2240 { lab=#net98}
N 3300 2160 3320 2160 { lab=#net97}
N 3440 2050 3440 2060 { lab=#net5}
N 3640 2100 3650 2100 { lab=VDD}
N 3650 2080 3650 2100 { lab=VDD}
N 3620 2140 3620 2200 { lab=#net8}
N 3620 2240 3620 2260 { lab=#net8}
N 3620 2050 3620 2110 { lab=#net8}
N 3620 2200 3620 2240 { lab=#net8}
N 3620 2110 3620 2140 { lab=#net8}
N 3540 2050 3540 2260 { lab=#net7}
N 3480 2160 3660 2160 { lab=#net97}
N 3580 2100 3590 2100 { lab=#net97}
N 3580 2100 3580 2160 { lab=#net97}
N 3480 2240 3590 2240 { lab=#net99}
N 3650 2240 3660 2240 { lab=#net100}
N 3480 2080 3660 2080 { lab=VDD}
N 3690 2160 3840 2160 { lab=#net97}
N 3750 2100 3760 2100 { lab=#net97}
N 3760 2100 3760 2160 { lab=#net97}
N 3680 2160 3690 2160 { lab=#net97}
N 3690 2080 3690 2100 { lab=VDD}
N 3680 2240 3690 2240 { lab=#net100}
N 3750 2240 3840 2240 { lab=#net101}
N 3720 2140 3720 2200 { lab=#net10}
N 3720 2240 3720 2260 { lab=#net10}
N 3720 2050 3720 2110 { lab=#net10}
N 3660 2080 3840 2080 { lab=VDD}
N 3800 2060 3800 2260 { lab=#net11}
N 3720 2200 3720 2240 { lab=#net10}
N 3720 2110 3720 2140 { lab=#net10}
N 3660 2240 3680 2240 { lab=#net100}
N 3660 2160 3680 2160 { lab=#net97}
N 3800 2050 3800 2060 { lab=#net11}
N 4000 2100 4010 2100 { lab=VDD}
N 4010 2080 4010 2100 { lab=VDD}
N 3980 2140 3980 2200 { lab=#net12}
N 3980 2240 3980 2260 { lab=#net12}
N 3980 2050 3980 2110 { lab=#net12}
N 3980 2200 3980 2240 { lab=#net12}
N 3980 2110 3980 2140 { lab=#net12}
N 3900 2050 3900 2260 { lab=#net13}
N 3840 2160 4020 2160 { lab=#net97}
N 3940 2100 3950 2100 { lab=#net97}
N 3940 2100 3940 2160 { lab=#net97}
N 3840 2240 3950 2240 { lab=#net101}
N 4010 2240 4020 2240 { lab=#net102}
N 3840 2080 4020 2080 { lab=VDD}
N 4180 2100 4190 2100 { lab=VDD}
N 4190 2080 4190 2100 { lab=VDD}
N 4160 2140 4160 2200 { lab=#net15}
N 4160 2240 4160 2260 { lab=#net15}
N 4160 2050 4160 2110 { lab=#net15}
N 4160 2200 4160 2240 { lab=#net15}
N 4160 2110 4160 2140 { lab=#net15}
N 4080 2050 4080 2260 { lab=#net16}
N 4020 2160 4200 2160 { lab=#net97}
N 4120 2100 4130 2100 { lab=#net97}
N 4120 2100 4120 2160 { lab=#net97}
N 4020 2240 4130 2240 { lab=#net102}
N 4190 2240 4200 2240 { lab=#net97}
N 4020 2080 4200 2080 { lab=VDD}
N 3280 2310 3290 2310 { lab=VDD}
N 3290 2290 3290 2310 { lab=VDD}
N 3260 2350 3260 2410 { lab=#net18}
N 3260 2450 3260 2470 { lab=#net18}
N 3260 2260 3260 2320 { lab=#net18}
N 3260 2410 3260 2450 { lab=#net18}
N 3260 2320 3260 2350 { lab=#net18}
N 3180 2260 3180 2470 { lab=#net17}
N 3120 2370 3300 2370 { lab=#net103}
N 3220 2310 3230 2310 { lab=#net103}
N 3220 2310 3220 2370 { lab=#net103}
N 3120 2450 3230 2450 { lab=GND}
N 3290 2450 3300 2450 { lab=#net104}
N 3120 2290 3300 2290 { lab=VDD}
N 3640 2310 3650 2310 { lab=VDD}
N 3650 2290 3650 2310 { lab=VDD}
N 3620 2350 3620 2410 { lab=#net8}
N 3620 2450 3620 2470 { lab=#net8}
N 3620 2260 3620 2320 { lab=#net8}
N 3620 2410 3620 2450 { lab=#net8}
N 3620 2320 3620 2350 { lab=#net8}
N 3540 2260 3540 2470 { lab=#net7}
N 3480 2370 3660 2370 { lab=#net103}
N 3580 2310 3590 2310 { lab=#net103}
N 3580 2310 3580 2370 { lab=#net103}
N 3480 2450 3590 2450 { lab=#net105}
N 3650 2450 3660 2450 { lab=#net106}
N 3480 2290 3660 2290 { lab=VDD}
N 3820 2310 3830 2310 { lab=VDD}
N 3830 2290 3830 2310 { lab=VDD}
N 3800 2350 3800 2410 { lab=#net11}
N 3800 2450 3800 2470 { lab=#net11}
N 3800 2260 3800 2320 { lab=#net11}
N 3800 2410 3800 2450 { lab=#net11}
N 3800 2320 3800 2350 { lab=#net11}
N 3720 2260 3720 2470 { lab=#net10}
N 3660 2370 3840 2370 { lab=#net103}
N 3760 2310 3770 2310 { lab=#net103}
N 3760 2310 3760 2370 { lab=#net103}
N 3660 2450 3770 2450 { lab=#net106}
N 3830 2450 3840 2450 { lab=#net107}
N 3660 2290 3840 2290 { lab=VDD}
N 4000 2310 4010 2310 { lab=VDD}
N 4010 2290 4010 2310 { lab=VDD}
N 3980 2350 3980 2410 { lab=#net12}
N 3980 2450 3980 2470 { lab=#net12}
N 3980 2260 3980 2320 { lab=#net12}
N 3980 2410 3980 2450 { lab=#net12}
N 3980 2320 3980 2350 { lab=#net12}
N 3900 2260 3900 2470 { lab=#net13}
N 3840 2370 4020 2370 { lab=#net103}
N 3940 2310 3950 2310 { lab=#net103}
N 3940 2310 3940 2370 { lab=#net103}
N 3840 2450 3950 2450 { lab=#net107}
N 4010 2450 4020 2450 { lab=#net108}
N 3840 2290 4020 2290 { lab=VDD}
N 4180 2310 4190 2310 { lab=VDD}
N 4190 2290 4190 2310 { lab=VDD}
N 4160 2350 4160 2410 { lab=#net15}
N 4160 2450 4160 2470 { lab=#net15}
N 4160 2260 4160 2320 { lab=#net15}
N 4160 2410 4160 2450 { lab=#net15}
N 4160 2320 4160 2350 { lab=#net15}
N 4080 2260 4080 2470 { lab=#net16}
N 4020 2370 4200 2370 { lab=#net103}
N 4120 2310 4130 2310 { lab=#net103}
N 4120 2310 4120 2370 { lab=#net103}
N 4020 2450 4130 2450 { lab=#net108}
N 4190 2450 4200 2450 { lab=#net103}
N 4020 2290 4200 2290 { lab=VDD}
N 3330 2370 3480 2370 { lab=#net103}
N 3390 2310 3400 2310 { lab=#net103}
N 3400 2310 3400 2370 { lab=#net103}
N 3320 2370 3330 2370 { lab=#net103}
N 3330 2290 3330 2310 { lab=VDD}
N 3320 2450 3330 2450 { lab=#net104}
N 3390 2450 3480 2450 { lab=#net105}
N 3360 2350 3360 2410 { lab=#net4}
N 3360 2450 3360 2470 { lab=#net4}
N 3360 2260 3360 2320 { lab=#net4}
N 3300 2290 3480 2290 { lab=VDD}
N 3440 2270 3440 2470 { lab=#net5}
N 3360 2410 3360 2450 { lab=#net4}
N 3360 2320 3360 2350 { lab=#net4}
N 3300 2450 3320 2450 { lab=#net104}
N 3300 2370 3320 2370 { lab=#net103}
N 3440 2260 3440 2270 { lab=#net5}
N 3280 2520 3290 2520 { lab=VDD}
N 3290 2500 3290 2520 { lab=VDD}
N 3260 2560 3260 2620 { lab=#net18}
N 3260 2660 3260 2680 { lab=#net18}
N 3260 2470 3260 2530 { lab=#net18}
N 3260 2620 3260 2660 { lab=#net18}
N 3260 2530 3260 2560 { lab=#net18}
N 3180 2470 3180 2680 { lab=#net17}
N 3120 2580 3300 2580 { lab=#net109}
N 3220 2520 3230 2520 { lab=#net109}
N 3220 2520 3220 2580 { lab=#net109}
N 3120 2660 3230 2660 { lab=GND}
N 3290 2660 3300 2660 { lab=#net110}
N 3120 2500 3300 2500 { lab=VDD}
N 3640 2520 3650 2520 { lab=VDD}
N 3650 2500 3650 2520 { lab=VDD}
N 3620 2560 3620 2620 { lab=#net8}
N 3620 2660 3620 2680 { lab=#net8}
N 3620 2470 3620 2530 { lab=#net8}
N 3620 2620 3620 2660 { lab=#net8}
N 3620 2530 3620 2560 { lab=#net8}
N 3540 2470 3540 2680 { lab=#net7}
N 3480 2580 3660 2580 { lab=#net109}
N 3580 2520 3590 2520 { lab=#net109}
N 3580 2520 3580 2580 { lab=#net109}
N 3480 2660 3590 2660 { lab=#net111}
N 3650 2660 3660 2660 { lab=#net112}
N 3480 2500 3660 2500 { lab=VDD}
N 3820 2520 3830 2520 { lab=VDD}
N 3830 2500 3830 2520 { lab=VDD}
N 3800 2560 3800 2620 { lab=#net11}
N 3800 2660 3800 2680 { lab=#net11}
N 3800 2470 3800 2530 { lab=#net11}
N 3800 2620 3800 2660 { lab=#net11}
N 3800 2530 3800 2560 { lab=#net11}
N 3720 2470 3720 2680 { lab=#net10}
N 3660 2580 3840 2580 { lab=#net109}
N 3760 2520 3770 2520 { lab=#net109}
N 3760 2520 3760 2580 { lab=#net109}
N 3660 2660 3770 2660 { lab=#net112}
N 3830 2660 3840 2660 { lab=#net113}
N 3660 2500 3840 2500 { lab=VDD}
N 3330 2580 3480 2580 { lab=#net109}
N 3390 2520 3400 2520 { lab=#net109}
N 3400 2520 3400 2580 { lab=#net109}
N 3320 2580 3330 2580 { lab=#net109}
N 3330 2500 3330 2520 { lab=VDD}
N 3320 2660 3330 2660 { lab=#net110}
N 3390 2660 3480 2660 { lab=#net111}
N 3360 2560 3360 2620 { lab=#net4}
N 3360 2660 3360 2680 { lab=#net4}
N 3360 2470 3360 2530 { lab=#net4}
N 3300 2500 3480 2500 { lab=VDD}
N 3440 2480 3440 2680 { lab=#net5}
N 3360 2620 3360 2660 { lab=#net4}
N 3360 2530 3360 2560 { lab=#net4}
N 3300 2660 3320 2660 { lab=#net110}
N 3300 2580 3320 2580 { lab=#net109}
N 3440 2470 3440 2480 { lab=#net5}
N 3870 2580 4020 2580 { lab=#net109}
N 3930 2520 3940 2520 { lab=#net109}
N 3940 2520 3940 2580 { lab=#net109}
N 3860 2580 3870 2580 { lab=#net109}
N 3870 2500 3870 2520 { lab=VDD}
N 3860 2660 3870 2660 { lab=#net113}
N 3930 2660 4020 2660 { lab=#net114}
N 3900 2560 3900 2620 { lab=#net13}
N 3900 2660 3900 2680 { lab=#net13}
N 3900 2470 3900 2530 { lab=#net13}
N 3840 2500 4020 2500 { lab=VDD}
N 3980 2480 3980 2680 { lab=#net12}
N 3900 2620 3900 2660 { lab=#net13}
N 3900 2530 3900 2560 { lab=#net13}
N 3840 2660 3860 2660 { lab=#net113}
N 3840 2580 3860 2580 { lab=#net109}
N 3980 2470 3980 2480 { lab=#net12}
N 4180 2520 4190 2520 { lab=VDD}
N 4190 2500 4190 2520 { lab=VDD}
N 4160 2560 4160 2620 { lab=#net15}
N 4160 2660 4160 2680 { lab=#net15}
N 4160 2470 4160 2530 { lab=#net15}
N 4160 2620 4160 2660 { lab=#net15}
N 4160 2530 4160 2560 { lab=#net15}
N 4080 2470 4080 2680 { lab=#net16}
N 4020 2580 4200 2580 { lab=#net109}
N 4120 2520 4130 2520 { lab=#net109}
N 4120 2520 4120 2580 { lab=#net109}
N 4020 2660 4130 2660 { lab=#net114}
N 4190 2660 4200 2660 { lab=#net109}
N 4020 2500 4200 2500 { lab=VDD}
N 3280 2730 3290 2730 { lab=VDD}
N 3290 2710 3290 2730 { lab=VDD}
N 3260 2770 3260 2830 { lab=#net18}
N 3260 2870 3260 2890 { lab=#net18}
N 3260 2680 3260 2740 { lab=#net18}
N 3260 2830 3260 2870 { lab=#net18}
N 3260 2740 3260 2770 { lab=#net18}
N 3180 2680 3180 2890 { lab=#net17}
N 3120 2790 3300 2790 { lab=#net115}
N 3220 2730 3230 2730 { lab=#net115}
N 3220 2730 3220 2790 { lab=#net115}
N 3120 2870 3230 2870 { lab=GND}
N 3290 2870 3300 2870 { lab=#net116}
N 3120 2710 3300 2710 { lab=VDD}
N 3330 2790 3480 2790 { lab=#net115}
N 3390 2730 3400 2730 { lab=#net115}
N 3400 2730 3400 2790 { lab=#net115}
N 3320 2790 3330 2790 { lab=#net115}
N 3330 2710 3330 2730 { lab=VDD}
N 3320 2870 3330 2870 { lab=#net116}
N 3390 2870 3480 2870 { lab=#net117}
N 3360 2770 3360 2830 { lab=#net4}
N 3360 2870 3360 2890 { lab=#net4}
N 3360 2680 3360 2740 { lab=#net4}
N 3300 2710 3480 2710 { lab=VDD}
N 3440 2690 3440 2890 { lab=#net5}
N 3360 2830 3360 2870 { lab=#net4}
N 3360 2740 3360 2770 { lab=#net4}
N 3300 2870 3320 2870 { lab=#net116}
N 3300 2790 3320 2790 { lab=#net115}
N 3440 2680 3440 2690 { lab=#net5}
N 3510 2790 3660 2790 { lab=#net115}
N 3570 2730 3580 2730 { lab=#net115}
N 3580 2730 3580 2790 { lab=#net115}
N 3500 2790 3510 2790 { lab=#net115}
N 3510 2710 3510 2730 { lab=VDD}
N 3500 2870 3510 2870 { lab=#net117}
N 3570 2870 3660 2870 { lab=#net118}
N 3540 2770 3540 2830 { lab=#net7}
N 3540 2870 3540 2890 { lab=#net7}
N 3540 2680 3540 2740 { lab=#net7}
N 3480 2710 3660 2710 { lab=VDD}
N 3620 2690 3620 2890 { lab=#net8}
N 3540 2830 3540 2870 { lab=#net7}
N 3540 2740 3540 2770 { lab=#net7}
N 3480 2870 3500 2870 { lab=#net117}
N 3480 2790 3500 2790 { lab=#net115}
N 3620 2680 3620 2690 { lab=#net8}
N 3820 2730 3830 2730 { lab=VDD}
N 3830 2710 3830 2730 { lab=VDD}
N 3800 2770 3800 2830 { lab=#net11}
N 3800 2870 3800 2890 { lab=#net11}
N 3800 2680 3800 2740 { lab=#net11}
N 3800 2830 3800 2870 { lab=#net11}
N 3800 2740 3800 2770 { lab=#net11}
N 3720 2680 3720 2890 { lab=#net10}
N 3660 2790 3840 2790 { lab=#net115}
N 3760 2730 3770 2730 { lab=#net115}
N 3760 2730 3760 2790 { lab=#net115}
N 3660 2870 3770 2870 { lab=#net118}
N 3830 2870 3840 2870 { lab=#net119}
N 3660 2710 3840 2710 { lab=VDD}
N 4000 2730 4010 2730 { lab=VDD}
N 4010 2710 4010 2730 { lab=VDD}
N 3980 2770 3980 2830 { lab=#net12}
N 3980 2870 3980 2890 { lab=#net12}
N 3980 2680 3980 2740 { lab=#net12}
N 3980 2830 3980 2870 { lab=#net12}
N 3980 2740 3980 2770 { lab=#net12}
N 3900 2680 3900 2890 { lab=#net13}
N 3840 2790 4020 2790 { lab=#net115}
N 3940 2730 3950 2730 { lab=#net115}
N 3940 2730 3940 2790 { lab=#net115}
N 3840 2870 3950 2870 { lab=#net119}
N 4010 2870 4020 2870 { lab=#net120}
N 3840 2710 4020 2710 { lab=VDD}
N 4050 2790 4200 2790 { lab=#net115}
N 4110 2730 4120 2730 { lab=#net115}
N 4120 2730 4120 2790 { lab=#net115}
N 4040 2790 4050 2790 { lab=#net115}
N 4050 2710 4050 2730 { lab=VDD}
N 4040 2870 4050 2870 { lab=#net120}
N 4110 2870 4200 2870 { lab=#net115}
N 4080 2770 4080 2830 { lab=#net16}
N 4080 2870 4080 2890 { lab=#net16}
N 4080 2680 4080 2740 { lab=#net16}
N 4020 2710 4200 2710 { lab=VDD}
N 4160 2690 4160 2890 { lab=#net15}
N 4080 2830 4080 2870 { lab=#net16}
N 4080 2740 4080 2770 { lab=#net16}
N 4020 2870 4040 2870 { lab=#net120}
N 4020 2790 4040 2790 { lab=#net115}
N 4160 2680 4160 2690 { lab=#net15}
N 3280 2940 3290 2940 { lab=VDD}
N 3290 2920 3290 2940 { lab=VDD}
N 3260 2980 3260 3040 { lab=#net18}
N 3260 3080 3260 3100 { lab=#net18}
N 3260 2890 3260 2950 { lab=#net18}
N 3260 3040 3260 3080 { lab=#net18}
N 3260 2950 3260 2980 { lab=#net18}
N 3180 2890 3180 3100 { lab=#net17}
N 3120 3000 3300 3000 { lab=#net121}
N 3220 2940 3230 2940 { lab=#net121}
N 3220 2940 3220 3000 { lab=#net121}
N 3120 3080 3230 3080 { lab=GND}
N 3290 3080 3300 3080 { lab=#net122}
N 3120 2920 3300 2920 { lab=VDD}
N 3330 3000 3480 3000 { lab=#net121}
N 3390 2940 3400 2940 { lab=#net121}
N 3400 2940 3400 3000 { lab=#net121}
N 3320 3000 3330 3000 { lab=#net121}
N 3330 2920 3330 2940 { lab=VDD}
N 3320 3080 3330 3080 { lab=#net122}
N 3390 3080 3480 3080 { lab=#net123}
N 3360 2980 3360 3040 { lab=#net4}
N 3360 3080 3360 3100 { lab=#net4}
N 3360 2890 3360 2950 { lab=#net4}
N 3300 2920 3480 2920 { lab=VDD}
N 3440 2900 3440 3100 { lab=#net5}
N 3360 3040 3360 3080 { lab=#net4}
N 3360 2950 3360 2980 { lab=#net4}
N 3300 3080 3320 3080 { lab=#net122}
N 3300 3000 3320 3000 { lab=#net121}
N 3440 2890 3440 2900 { lab=#net5}
N 3510 3000 3660 3000 { lab=#net121}
N 3570 2940 3580 2940 { lab=#net121}
N 3580 2940 3580 3000 { lab=#net121}
N 3500 3000 3510 3000 { lab=#net121}
N 3510 2920 3510 2940 { lab=VDD}
N 3500 3080 3510 3080 { lab=#net123}
N 3570 3080 3660 3080 { lab=#net124}
N 3540 2980 3540 3040 { lab=#net7}
N 3540 3080 3540 3100 { lab=#net7}
N 3540 2890 3540 2950 { lab=#net7}
N 3480 2920 3660 2920 { lab=VDD}
N 3620 2900 3620 3100 { lab=#net8}
N 3540 3040 3540 3080 { lab=#net7}
N 3540 2950 3540 2980 { lab=#net7}
N 3480 3080 3500 3080 { lab=#net123}
N 3480 3000 3500 3000 { lab=#net121}
N 3620 2890 3620 2900 { lab=#net8}
N 3690 3000 3840 3000 { lab=#net121}
N 3750 2940 3760 2940 { lab=#net121}
N 3760 2940 3760 3000 { lab=#net121}
N 3680 3000 3690 3000 { lab=#net121}
N 3690 2920 3690 2940 { lab=VDD}
N 3680 3080 3690 3080 { lab=#net124}
N 3750 3080 3840 3080 { lab=#net125}
N 3720 2980 3720 3040 { lab=#net10}
N 3720 3080 3720 3100 { lab=#net10}
N 3720 2890 3720 2950 { lab=#net10}
N 3660 2920 3840 2920 { lab=VDD}
N 3800 2900 3800 3100 { lab=#net11}
N 3720 3040 3720 3080 { lab=#net10}
N 3720 2950 3720 2980 { lab=#net10}
N 3660 3080 3680 3080 { lab=#net124}
N 3660 3000 3680 3000 { lab=#net121}
N 3800 2890 3800 2900 { lab=#net11}
N 4000 2940 4010 2940 { lab=VDD}
N 4010 2920 4010 2940 { lab=VDD}
N 3980 2980 3980 3040 { lab=#net12}
N 3980 3080 3980 3100 { lab=#net12}
N 3980 2890 3980 2950 { lab=#net12}
N 3980 3040 3980 3080 { lab=#net12}
N 3980 2950 3980 2980 { lab=#net12}
N 3900 2890 3900 3100 { lab=#net13}
N 3840 3000 4020 3000 { lab=#net121}
N 3940 2940 3950 2940 { lab=#net121}
N 3940 2940 3940 3000 { lab=#net121}
N 3840 3080 3950 3080 { lab=#net125}
N 4010 3080 4020 3080 { lab=#net126}
N 3840 2920 4020 2920 { lab=VDD}
N 4050 3000 4200 3000 { lab=#net121}
N 4110 2940 4120 2940 { lab=#net121}
N 4120 2940 4120 3000 { lab=#net121}
N 4040 3000 4050 3000 { lab=#net121}
N 4050 2920 4050 2940 { lab=VDD}
N 4040 3080 4050 3080 { lab=#net126}
N 4110 3080 4200 3080 { lab=#net121}
N 4080 2980 4080 3040 { lab=#net16}
N 4080 3080 4080 3100 { lab=#net16}
N 4080 2890 4080 2950 { lab=#net16}
N 4020 2920 4200 2920 { lab=VDD}
N 4160 2900 4160 3100 { lab=#net15}
N 4080 3040 4080 3080 { lab=#net16}
N 4080 2950 4080 2980 { lab=#net16}
N 4020 3080 4040 3080 { lab=#net126}
N 4020 3000 4040 3000 { lab=#net121}
N 4160 2890 4160 2900 { lab=#net15}
N 3280 3150 3290 3150 { lab=VDD}
N 3290 3130 3290 3150 { lab=VDD}
N 3260 3190 3260 3250 { lab=#net18}
N 3260 3290 3260 3310 { lab=#net18}
N 3260 3100 3260 3160 { lab=#net18}
N 3260 3250 3260 3290 { lab=#net18}
N 3260 3160 3260 3190 { lab=#net18}
N 3180 3100 3180 3310 { lab=#net17}
N 3120 3210 3300 3210 { lab=#net127}
N 3220 3150 3230 3150 { lab=#net127}
N 3220 3150 3220 3210 { lab=#net127}
N 3120 3290 3230 3290 { lab=GND}
N 3290 3290 3300 3290 { lab=#net128}
N 3120 3130 3300 3130 { lab=VDD}
N 3330 3210 3480 3210 { lab=#net127}
N 3390 3150 3400 3150 { lab=#net127}
N 3400 3150 3400 3210 { lab=#net127}
N 3320 3210 3330 3210 { lab=#net127}
N 3330 3130 3330 3150 { lab=VDD}
N 3320 3290 3330 3290 { lab=#net128}
N 3390 3290 3480 3290 { lab=#net129}
N 3360 3190 3360 3250 { lab=#net4}
N 3360 3290 3360 3310 { lab=#net4}
N 3360 3100 3360 3160 { lab=#net4}
N 3300 3130 3480 3130 { lab=VDD}
N 3440 3110 3440 3310 { lab=#net5}
N 3360 3250 3360 3290 { lab=#net4}
N 3360 3160 3360 3190 { lab=#net4}
N 3300 3290 3320 3290 { lab=#net128}
N 3300 3210 3320 3210 { lab=#net127}
N 3440 3100 3440 3110 { lab=#net5}
N 3510 3210 3660 3210 { lab=#net127}
N 3570 3150 3580 3150 { lab=#net127}
N 3580 3150 3580 3210 { lab=#net127}
N 3500 3210 3510 3210 { lab=#net127}
N 3510 3130 3510 3150 { lab=VDD}
N 3500 3290 3510 3290 { lab=#net129}
N 3570 3290 3660 3290 { lab=#net130}
N 3540 3190 3540 3250 { lab=#net7}
N 3540 3290 3540 3310 { lab=#net7}
N 3540 3100 3540 3160 { lab=#net7}
N 3480 3130 3660 3130 { lab=VDD}
N 3620 3110 3620 3310 { lab=#net8}
N 3540 3250 3540 3290 { lab=#net7}
N 3540 3160 3540 3190 { lab=#net7}
N 3480 3290 3500 3290 { lab=#net129}
N 3480 3210 3500 3210 { lab=#net127}
N 3620 3100 3620 3110 { lab=#net8}
N 3690 3210 3840 3210 { lab=#net127}
N 3750 3150 3760 3150 { lab=#net127}
N 3760 3150 3760 3210 { lab=#net127}
N 3680 3210 3690 3210 { lab=#net127}
N 3690 3130 3690 3150 { lab=VDD}
N 3680 3290 3690 3290 { lab=#net130}
N 3750 3290 3840 3290 { lab=#net131}
N 3720 3190 3720 3250 { lab=#net10}
N 3720 3290 3720 3310 { lab=#net10}
N 3720 3100 3720 3160 { lab=#net10}
N 3660 3130 3840 3130 { lab=VDD}
N 3800 3110 3800 3310 { lab=#net11}
N 3720 3250 3720 3290 { lab=#net10}
N 3720 3160 3720 3190 { lab=#net10}
N 3660 3290 3680 3290 { lab=#net130}
N 3660 3210 3680 3210 { lab=#net127}
N 3800 3100 3800 3110 { lab=#net11}
N 4000 3150 4010 3150 { lab=VDD}
N 4010 3130 4010 3150 { lab=VDD}
N 3980 3190 3980 3250 { lab=#net12}
N 3980 3290 3980 3310 { lab=#net12}
N 3980 3100 3980 3160 { lab=#net12}
N 3980 3250 3980 3290 { lab=#net12}
N 3980 3160 3980 3190 { lab=#net12}
N 3900 3100 3900 3310 { lab=#net13}
N 3840 3210 4020 3210 { lab=#net127}
N 3940 3150 3950 3150 { lab=#net127}
N 3940 3150 3940 3210 { lab=#net127}
N 3840 3290 3950 3290 { lab=#net131}
N 4010 3290 4020 3290 { lab=#net132}
N 3840 3130 4020 3130 { lab=VDD}
N 4180 3150 4190 3150 { lab=VDD}
N 4190 3130 4190 3150 { lab=VDD}
N 4160 3190 4160 3250 { lab=#net15}
N 4160 3290 4160 3310 { lab=#net15}
N 4160 3100 4160 3160 { lab=#net15}
N 4160 3250 4160 3290 { lab=#net15}
N 4160 3160 4160 3190 { lab=#net15}
N 4080 3100 4080 3310 { lab=#net16}
N 4020 3210 4200 3210 { lab=#net127}
N 4120 3150 4130 3150 { lab=#net127}
N 4120 3150 4120 3210 { lab=#net127}
N 4020 3290 4130 3290 { lab=#net132}
N 4190 3290 4200 3290 { lab=#net127}
N 4020 3130 4200 3130 { lab=VDD}
N 3030 -970 3030 3130 { lab=VDD}
N 3030 3130 3120 3130 { lab=VDD}
N 3030 2920 3120 2920 { lab=VDD}
N 3030 2710 3120 2710 { lab=VDD}
N 3030 2500 3120 2500 { lab=VDD}
N 3030 2290 3120 2290 { lab=VDD}
N 3030 2080 3120 2080 { lab=VDD}
N 3030 1870 3120 1870 { lab=VDD}
N 3030 1660 3120 1660 { lab=VDD}
N 3030 1450 3120 1450 { lab=VDD}
N 3030 1240 3120 1240 { lab=VDD}
N 3030 1030 3120 1030 { lab=VDD}
N 3030 820 3120 820 { lab=VDD}
N 3030 610 3120 610 { lab=VDD}
N 3030 400 3120 400 { lab=VDD}
N 3030 190 3120 190 { lab=VDD}
N 3030 -20 3120 -20 { lab=VDD}
N 3030 -230 3120 -230 { lab=VDD}
N 3030 -440 3120 -440 { lab=VDD}
N 3030 -650 3120 -650 { lab=VDD}
N 3030 -860 3120 -860 { lab=VDD}
N 3080 -700 3120 -700 { lab=GND}
N 3080 -700 3080 3350 { lab=GND}
N 3080 3290 3120 3290 { lab=GND}
N 3080 3080 3120 3080 { lab=GND}
N 3080 2870 3120 2870 { lab=GND}
N 3080 2660 3120 2660 { lab=GND}
N 3080 2450 3120 2450 { lab=GND}
N 3080 2240 3120 2240 { lab=GND}
N 3080 2030 3120 2030 { lab=GND}
N 3080 1820 3120 1820 { lab=GND}
N 3080 1610 3120 1610 { lab=GND}
N 3080 1400 3120 1400 { lab=GND}
N 3080 1190 3120 1190 { lab=GND}
N 3080 980 3120 980 { lab=GND}
N 3080 770 3120 770 { lab=GND}
N 3080 560 3120 560 { lab=GND}
N 3080 350 3120 350 { lab=GND}
N 3080 140 3120 140 { lab=GND}
N 3080 -70 3120 -70 { lab=GND}
N 3080 -280 3120 -280 { lab=GND}
N 3080 -490 3120 -490 { lab=GND}
N 4260 -780 4260 -700 { lab=#net1}
N 4260 -780 4330 -780 { lab=#net1}
N 4200 -570 4260 -570 { lab=#net19}
N 4200 -490 4260 -490 { lab=#net19}
N 4260 -570 4260 -490 { lab=#net19}
N 4260 -570 4330 -570 { lab=#net19}
N 4200 -360 4260 -360 { lab=#net25}
N 4200 -280 4260 -280 { lab=#net25}
N 4260 -360 4260 -280 { lab=#net25}
N 4260 -360 4330 -360 { lab=#net25}
N 4200 -150 4260 -150 { lab=#net31}
N 4200 -70 4260 -70 { lab=#net31}
N 4260 -150 4260 -70 { lab=#net31}
N 4260 -150 4330 -150 { lab=#net31}
N 4200 60 4260 60 { lab=#net37}
N 4200 140 4260 140 { lab=#net37}
N 4260 60 4260 140 { lab=#net37}
N 4260 60 4330 60 { lab=#net37}
N 4200 270 4260 270 { lab=#net43}
N 4200 350 4260 350 { lab=#net43}
N 4260 270 4260 350 { lab=#net43}
N 4260 270 4330 270 { lab=#net43}
N 4200 480 4260 480 { lab=#net49}
N 4200 560 4260 560 { lab=#net49}
N 4260 480 4260 560 { lab=#net49}
N 4260 480 4330 480 { lab=#net49}
N 4200 690 4260 690 { lab=#net55}
N 4200 770 4260 770 { lab=#net55}
N 4260 690 4260 770 { lab=#net55}
N 4260 690 4330 690 { lab=#net55}
N 4200 900 4260 900 { lab=#net61}
N 4200 980 4260 980 { lab=#net61}
N 4260 900 4260 980 { lab=#net61}
N 4260 900 4330 900 { lab=#net61}
N 4200 1110 4260 1110 { lab=#net67}
N 4200 1190 4260 1190 { lab=#net67}
N 4260 1110 4260 1190 { lab=#net67}
N 4260 1110 4330 1110 { lab=#net67}
N 4200 1320 4260 1320 { lab=#net73}
N 4200 1400 4260 1400 { lab=#net73}
N 4260 1320 4260 1400 { lab=#net73}
N 4260 1320 4330 1320 { lab=#net73}
N 4200 1530 4260 1530 { lab=#net79}
N 4200 1610 4260 1610 { lab=#net79}
N 4260 1530 4260 1610 { lab=#net79}
N 4260 1530 4330 1530 { lab=#net79}
N 4200 1740 4260 1740 { lab=#net85}
N 4200 1820 4260 1820 { lab=#net85}
N 4260 1740 4260 1820 { lab=#net85}
N 4260 1740 4330 1740 { lab=#net85}
N 4200 1950 4260 1950 { lab=#net91}
N 4200 2030 4260 2030 { lab=#net91}
N 4260 1950 4260 2030 { lab=#net91}
N 4260 1950 4330 1950 { lab=#net91}
N 4200 2160 4260 2160 { lab=#net97}
N 4200 2240 4260 2240 { lab=#net97}
N 4260 2160 4260 2240 { lab=#net97}
N 4260 2160 4330 2160 { lab=#net97}
N 4200 2370 4260 2370 { lab=#net103}
N 4200 2450 4260 2450 { lab=#net103}
N 4260 2370 4260 2450 { lab=#net103}
N 4260 2370 4330 2370 { lab=#net103}
N 4200 2580 4260 2580 { lab=#net109}
N 4200 2660 4260 2660 { lab=#net109}
N 4260 2580 4260 2660 { lab=#net109}
N 4260 2580 4330 2580 { lab=#net109}
N 4200 2790 4260 2790 { lab=#net115}
N 4200 2870 4260 2870 { lab=#net115}
N 4260 2790 4260 2870 { lab=#net115}
N 4260 2790 4330 2790 { lab=#net115}
N 4200 3000 4260 3000 { lab=#net121}
N 4200 3080 4260 3080 { lab=#net121}
N 4260 3000 4260 3080 { lab=#net121}
N 4260 3000 4330 3000 { lab=#net121}
N 4200 3210 4260 3210 { lab=#net127}
N 4200 3290 4260 3290 { lab=#net127}
N 4260 3210 4260 3290 { lab=#net127}
N 4260 3210 4330 3210 { lab=#net127}
N 3260 3430 3260 3450 { lab=#net17}
N 3180 3450 3260 3450 { lab=#net17}
N 3180 3310 3180 3450 { lab=#net17}
N 3260 3310 3260 3330 { lab=#net18}
N 3260 3550 3260 3570 { lab=A5}
N 3440 3430 3440 3450 { lab=#net4}
N 3360 3450 3440 3450 { lab=#net4}
N 3360 3310 3360 3450 { lab=#net4}
N 3440 3310 3440 3330 { lab=#net5}
N 3440 3550 3440 3570 { lab=A4}
N 3620 3430 3620 3450 { lab=#net7}
N 3540 3450 3620 3450 { lab=#net7}
N 3540 3310 3540 3450 { lab=#net7}
N 3620 3310 3620 3330 { lab=#net8}
N 3620 3550 3620 3570 { lab=A3}
N 3800 3430 3800 3450 { lab=#net10}
N 3720 3450 3800 3450 { lab=#net10}
N 3720 3310 3720 3450 { lab=#net10}
N 3800 3310 3800 3330 { lab=#net11}
N 3800 3550 3800 3570 { lab=A2}
N 3980 3430 3980 3450 { lab=#net13}
N 3900 3450 3980 3450 { lab=#net13}
N 3900 3310 3900 3450 { lab=#net13}
N 3980 3310 3980 3330 { lab=#net12}
N 3980 3550 3980 3570 { lab=A1}
N 4160 3430 4160 3450 { lab=#net16}
N 4080 3450 4160 3450 { lab=#net16}
N 4080 3310 4080 3450 { lab=#net16}
N 4160 3310 4160 3330 { lab=#net15}
N 4160 3550 4160 3570 { lab=A0}
N 3260 3570 3260 3600 { lab=A5}
N 3260 3570 3260 3600 { lab=A5}
N 3440 3570 3440 3600 { lab=A4}
N 3620 3570 3620 3600 { lab=A3}
N 3800 3570 3800 3600 { lab=A2}
N 3980 3570 3980 3600 { lab=A1}
N 4160 3570 4160 3600 { lab=A0}
N 4430 3210 4450 3210 { lab=sel61}
N 4430 3000 4450 3000 { lab=sel60}
N 4430 2790 4450 2790 { lab=sel59}
N 4430 2580 4450 2580 { lab=sel54}
N 4430 2370 4450 2370 { lab=sel53}
N 4430 2160 4450 2160 { lab=sel50}
N 4430 1950 4450 1950 { lab=sel46}
N 4430 1740 4450 1740 { lab=sel42}
N 4430 1530 4450 1530 { lab=sel40}
N 4430 1110 4450 1110 { lab=sel31}
N 4430 900 4450 900 { lab=sel23}
N 4430 480 4450 480 { lab=sel17}
N 4430 270 4450 270 { lab=sel13}
N 4430 60 4450 60 { lab=sel10}
N 4430 -150 4450 -150 { lab=sel9}
N 4430 -360 4450 -360 { lab=sel4}
N 4430 -570 4450 -570 { lab=sel3}
N 4430 -780 4450 -780 { lab=sel2}
N 4430 1320 4450 1320 { lab=sel32}
N 4430 690 4450 690 { lab=sel21}
N 3080 3350 3080 3640 { lab=GND}
N 3080 3620 4320 3620 { lab=GND}
N 3290 3390 3290 3620 { lab=GND}
N 3470 3390 3470 3620 { lab=GND}
N 3650 3390 3650 3620 { lab=GND}
N 3830 3390 3830 3620 { lab=GND}
N 4010 3390 4010 3620 { lab=GND}
N 4190 3390 4190 3620 { lab=GND}
N 3030 3130 3030 3530 { lab=VDD}
N 3030 3530 3030 3540 { lab=VDD}
N 3030 3540 4250 3540 { lab=VDD}
N 3230 3390 3230 3540 { lab=VDD}
N 3410 3390 3410 3540 { lab=VDD}
N 3590 3390 3590 3540 { lab=VDD}
N 3770 3390 3770 3540 { lab=VDD}
N 3950 3390 3950 3540 { lab=VDD}
N 4130 3390 4130 3540 { lab=VDD}
N 4320 3620 4550 3620 { lab=GND}
N 4550 3620 4560 3620 { lab=GND}
N 4560 -750 4560 3620 { lab=GND}
N 4370 -750 4560 -750 { lab=GND}
N 4370 -540 4560 -540 { lab=GND}
N 4370 -330 4560 -330 { lab=GND}
N 4370 -120 4560 -120 { lab=GND}
N 4370 90 4560 90 { lab=GND}
N 4370 300 4560 300 { lab=GND}
N 4370 510 4560 510 { lab=GND}
N 4370 720 4560 720 { lab=GND}
N 4370 930 4560 930 { lab=GND}
N 4370 1140 4560 1140 { lab=GND}
N 4370 1350 4560 1350 { lab=GND}
N 4370 1560 4560 1560 { lab=GND}
N 4370 1770 4560 1770 { lab=GND}
N 4370 1980 4560 1980 { lab=GND}
N 4370 2190 4560 2190 { lab=GND}
N 4370 2400 4560 2400 { lab=GND}
N 4370 2610 4560 2610 { lab=GND}
N 4370 2820 4560 2820 { lab=GND}
N 4370 3030 4560 3030 { lab=GND}
N 4370 3240 4560 3240 { lab=GND}
N 4250 3540 4320 3540 { lab=VDD}
N 4320 3130 4320 3540 { lab=VDD}
N 4320 -810 4320 3130 { lab=VDD}
N 4320 -810 4370 -810 { lab=VDD}
N 4320 -600 4370 -600 { lab=VDD}
N 4320 -390 4370 -390 { lab=VDD}
N 4320 -180 4370 -180 { lab=VDD}
N 4320 30 4370 30 { lab=VDD}
N 4320 240 4370 240 { lab=VDD}
N 4320 450 4370 450 { lab=VDD}
N 4320 660 4370 660 { lab=VDD}
N 4320 870 4370 870 { lab=VDD}
N 4320 1080 4370 1080 { lab=VDD}
N 4320 1290 4370 1290 { lab=VDD}
N 4320 1500 4370 1500 { lab=VDD}
N 4320 1710 4370 1710 { lab=VDD}
N 4320 1920 4370 1920 { lab=VDD}
N 4320 2130 4370 2130 { lab=VDD}
N 4320 2340 4370 2340 { lab=VDD}
N 4320 2550 4370 2550 { lab=VDD}
N 4320 2760 4370 2760 { lab=VDD}
N 4320 2970 4370 2970 { lab=VDD}
N 4320 3180 4370 3180 { lab=VDD}
N 4430 3210 4450 3210 { lab=sel61}
N 4430 3000 4450 3000 { lab=sel60}
C {sky130_fd_pr/nfet3_01v8.sym} 3360 -720 1 0 {name=M1
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3360 -820 3 0 {name=M2
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3540 -720 1 0 {name=M5
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3540 -820 3 0 {name=M6
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3720 -720 1 0 {name=M7
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3720 -820 3 0 {name=M8
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3980 -720 3 1 {name=M11
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3980 -820 1 1 {name=M12
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 -720 3 1 {name=M13
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4160 -820 1 1 {name=M14
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3180 -720 1 0 {name=M15
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3180 -820 3 0 {name=M16
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3360 -510 1 0 {name=M17
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3360 -610 3 0 {name=M18
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3540 -510 1 0 {name=M19
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3540 -610 3 0 {name=M20
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3720 -510 1 0 {name=M21
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3720 -610 3 0 {name=M22
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3980 -510 3 1 {name=M23
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3980 -610 1 1 {name=M24
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3180 -510 1 0 {name=M25
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3180 -610 3 0 {name=M26
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4080 -510 1 0 {name=M27
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4080 -610 3 0 {name=M28
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3360 -300 1 0 {name=M29
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3360 -400 3 0 {name=M30
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3540 -300 1 0 {name=M31
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3540 -400 3 0 {name=M32
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3180 -300 1 0 {name=M33
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3180 -400 3 0 {name=M34
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3800 -300 3 1 {name=M35
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3800 -400 1 1 {name=M36
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3980 -300 3 1 {name=M37
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3980 -400 1 1 {name=M38
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4080 -300 1 0 {name=M39
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4080 -400 3 0 {name=M40
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3180 -90 1 0 {name=M41
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3180 -190 3 0 {name=M42
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3360 -90 1 0 {name=M43
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3360 -190 3 0 {name=M44
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3620 -90 3 1 {name=M45
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3620 -190 1 1 {name=M46
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3800 -90 3 1 {name=M47
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3800 -190 1 1 {name=M48
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3900 -90 1 0 {name=M49
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3900 -190 3 0 {name=M50
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 -90 3 1 {name=M51
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4160 -190 1 1 {name=M52
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3180 120 1 0 {name=M53
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3180 20 3 0 {name=M54
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3360 120 1 0 {name=M55
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3360 20 3 0 {name=M56
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3620 120 3 1 {name=M57
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3620 20 1 1 {name=M58
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3800 120 3 1 {name=M59
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3800 20 1 1 {name=M60
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3980 120 3 1 {name=M61
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3980 20 1 1 {name=M62
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 120 3 1 {name=M63
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4160 20 1 1 {name=M64
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3180 330 1 0 {name=M65
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3180 230 3 0 {name=M66
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3360 330 1 0 {name=M67
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3360 230 3 0 {name=M68
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3720 330 1 0 {name=M69
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3720 230 3 0 {name=M70
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3620 330 3 1 {name=M71
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3620 230 1 1 {name=M72
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3980 330 3 1 {name=M73
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3980 230 1 1 {name=M74
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 330 3 1 {name=M75
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4160 230 1 1 {name=M76
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3180 540 1 0 {name=M77
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3180 440 3 0 {name=M78
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3720 540 1 0 {name=M81
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3720 440 3 0 {name=M82
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3900 540 1 0 {name=M83
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3900 440 3 0 {name=M84
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3620 540 3 1 {name=M85
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3620 440 1 1 {name=M86
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 540 3 1 {name=M87
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4160 440 1 1 {name=M88
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3440 540 3 1 {name=M79
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3440 440 1 1 {name=M80
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3180 750 1 0 {name=M89
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3180 650 3 0 {name=M90
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3440 750 3 1 {name=M91
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3440 650 1 1 {name=M92
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3620 750 3 1 {name=M93
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3620 650 1 1 {name=M94
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3800 750 3 1 {name=M95
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3800 650 1 1 {name=M96
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3980 750 3 1 {name=M97
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3980 650 1 1 {name=M98
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 750 3 1 {name=M99
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4160 650 1 1 {name=M100
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3180 960 1 0 {name=M101
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3180 860 3 0 {name=M102
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3440 960 3 1 {name=M103
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3440 860 1 1 {name=M104
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3620 960 3 1 {name=M105
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3620 860 1 1 {name=M106
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3800 960 3 1 {name=M107
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3800 860 1 1 {name=M108
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3900 960 1 0 {name=M109
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3900 860 3 0 {name=M110
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4080 960 1 0 {name=M111
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4080 860 3 0 {name=M112
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3180 1170 1 0 {name=M113
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3180 1070 3 0 {name=M114
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3440 1170 3 1 {name=M115
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3440 1070 1 1 {name=M116
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3540 1170 1 0 {name=M117
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3540 1070 3 0 {name=M118
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3720 1170 1 0 {name=M119
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3720 1070 3 0 {name=M120
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3900 1170 1 0 {name=M121
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3900 1070 3 0 {name=M122
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4080 1170 1 0 {name=M123
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4080 1070 3 0 {name=M124
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3260 1380 3 1 {name=M125
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3260 1280 1 1 {name=M126
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3440 1380 3 1 {name=M127
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3440 1280 1 1 {name=M128
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3540 1380 1 0 {name=M129
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3540 1280 3 0 {name=M130
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3720 1380 1 0 {name=M131
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3720 1280 3 0 {name=M132
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3900 1380 1 0 {name=M133
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3900 1280 3 0 {name=M134
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4080 1380 1 0 {name=M135
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4080 1280 3 0 {name=M136
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3260 1590 3 1 {name=M137
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3260 1490 1 1 {name=M138
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3440 1590 3 1 {name=M139
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3440 1490 1 1 {name=M140
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3620 1590 3 1 {name=M141
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3620 1490 1 1 {name=M142
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3800 1590 3 1 {name=M143
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3800 1490 1 1 {name=M144
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3900 1590 1 0 {name=M145
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3900 1490 3 0 {name=M146
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4080 1590 1 0 {name=M147
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4080 1490 3 0 {name=M148
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3260 1800 3 1 {name=M149
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3260 1700 1 1 {name=M150
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3440 1800 3 1 {name=M151
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3440 1700 1 1 {name=M152
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3620 1800 3 1 {name=M153
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3620 1700 1 1 {name=M154
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3800 1800 3 1 {name=M155
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3800 1700 1 1 {name=M156
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3980 1800 3 1 {name=M157
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3980 1700 1 1 {name=M158
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 1800 3 1 {name=M159
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4160 1700 1 1 {name=M160
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3260 2010 3 1 {name=M161
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3260 1910 1 1 {name=M162
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3440 2010 3 1 {name=M163
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3440 1910 1 1 {name=M164
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3620 2010 3 1 {name=M165
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3620 1910 1 1 {name=M166
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3720 2010 1 0 {name=M167
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3720 1910 3 0 {name=M168
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3900 2010 1 0 {name=M169
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3900 1910 3 0 {name=M170
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 2010 3 1 {name=M171
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4160 1910 1 1 {name=M172
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3260 2220 3 1 {name=M173
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3260 2120 1 1 {name=M174
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3360 2220 1 0 {name=M175
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3360 2120 3 0 {name=M176
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3620 2220 3 1 {name=M177
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3620 2120 1 1 {name=M178
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3720 2220 1 0 {name=M179
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3720 2120 3 0 {name=M180
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3980 2220 3 1 {name=M181
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3980 2120 1 1 {name=M182
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 2220 3 1 {name=M183
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4160 2120 1 1 {name=M184
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3260 2430 3 1 {name=M185
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3260 2330 1 1 {name=M186
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3620 2430 3 1 {name=M187
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3620 2330 1 1 {name=M188
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3800 2430 3 1 {name=M189
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3800 2330 1 1 {name=M190
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3980 2430 3 1 {name=M191
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3980 2330 1 1 {name=M192
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 2430 3 1 {name=M193
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4160 2330 1 1 {name=M194
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3360 2430 1 0 {name=M195
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3360 2330 3 0 {name=M196
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3260 2640 3 1 {name=M197
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3260 2540 1 1 {name=M198
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3620 2640 3 1 {name=M199
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3620 2540 1 1 {name=M200
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3800 2640 3 1 {name=M201
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3800 2540 1 1 {name=M202
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3360 2640 1 0 {name=M203
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3360 2540 3 0 {name=M204
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3900 2640 1 0 {name=M205
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3900 2540 3 0 {name=M206
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 2640 3 1 {name=M207
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4160 2540 1 1 {name=M208
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3260 2850 3 1 {name=M209
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3260 2750 1 1 {name=M210
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3360 2850 1 0 {name=M211
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3360 2750 3 0 {name=M212
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3540 2850 1 0 {name=M213
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3540 2750 3 0 {name=M214
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3800 2850 3 1 {name=M215
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3800 2750 1 1 {name=M216
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3980 2850 3 1 {name=M217
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3980 2750 1 1 {name=M218
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4080 2850 1 0 {name=M219
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4080 2750 3 0 {name=M220
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3260 3060 3 1 {name=M221
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3260 2960 1 1 {name=M222
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3360 3060 1 0 {name=M223
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3360 2960 3 0 {name=M224
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3540 3060 1 0 {name=M225
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3540 2960 3 0 {name=M226
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3720 3060 1 0 {name=M227
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3720 2960 3 0 {name=M228
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3980 3060 3 1 {name=M229
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3980 2960 1 1 {name=M230
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4080 3060 1 0 {name=M231
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4080 2960 3 0 {name=M232
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3260 3270 3 1 {name=M233
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3260 3170 1 1 {name=M234
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3360 3270 1 0 {name=M235
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3360 3170 3 0 {name=M236
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3540 3270 1 0 {name=M237
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3540 3170 3 0 {name=M238
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3720 3270 1 0 {name=M239
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3720 3170 3 0 {name=M240
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 3980 3270 3 1 {name=M241
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 3980 3170 1 1 {name=M242
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 4160 3270 3 1 {name=M243
L=0.15
W=0.42
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 4160 3170 1 1 {name=M244
L=0.15
W=0.42
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 3260 3590 3 0 {name=p9 lab=A5}
C {devices/ipin.sym} 3440 3590 3 0 {name=p10 lab=A4}
C {devices/ipin.sym} 3620 3590 3 0 {name=p11 lab=A3}
C {devices/ipin.sym} 3800 3590 3 0 {name=p12 lab=A2}
C {devices/ipin.sym} 3980 3590 3 0 {name=p13 lab=A1}
C {devices/ipin.sym} 4160 3590 3 0 {name=p14 lab=A0}
C {devices/opin.sym} 4440 3210 0 0 {name=p2 lab=sel61}
C {devices/opin.sym} 4440 3000 0 0 {name=p3 lab=sel60}
C {devices/opin.sym} 4440 2790 0 0 {name=p4 lab=sel59}
C {devices/opin.sym} 4440 2580 0 0 {name=p18 lab=sel54}
C {devices/opin.sym} 4440 2370 0 0 {name=p19 lab=sel53}
C {devices/opin.sym} 4440 2160 0 0 {name=p22 lab=sel50}
C {devices/opin.sym} 4440 1950 0 0 {name=p26 lab=sel46}
C {devices/opin.sym} 4440 1740 0 0 {name=p30 lab=sel42}
C {devices/opin.sym} 4440 1530 0 0 {name=p32 lab=sel40}
C {devices/opin.sym} 4440 1110 0 0 {name=p41 lab=sel31}
C {devices/opin.sym} 4440 900 0 0 {name=p49 lab=sel23}
C {devices/opin.sym} 4440 690 0 0 {name=p51 lab=sel21}
C {devices/opin.sym} 4440 480 0 0 {name=p55 lab=sel17}
C {devices/opin.sym} 4440 270 0 0 {name=p59 lab=sel13}
C {devices/opin.sym} 4440 60 0 0 {name=p62 lab=sel10}
C {devices/opin.sym} 4440 -150 0 0 {name=p63 lab=sel9}
C {devices/opin.sym} 4440 -360 0 0 {name=p68 lab=sel4}
C {devices/opin.sym} 4440 -570 0 0 {name=p69 lab=sel3}
C {devices/opin.sym} 4440 -780 0 0 {name=p70 lab=sel2}
C {devices/opin.sym} 4440 1320 0 0 {name=p5 lab=sel32}
C {inv/inv_sparse_decoder.sym} 4610 -660 0 0 {name=X20 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4610 -450 0 0 {name=X1 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4610 -240 0 0 {name=X2 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4610 180 0 0 {name=X4 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4610 600 0 0 {name=X6 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4610 1020 0 0 {name=X8 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4610 1440 0 0 {name=X10 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4610 1860 0 0 {name=X12 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4610 2280 0 0 {name=X14 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4610 2700 0 0 {name=X16 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4610 3120 0 0 {name=X18 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4280 3150 3 0 {name=X21 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4280 3270 3 0 {name=X22 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4100 3270 3 0 {name=X23 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 4100 3150 3 0 {name=X24 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 3920 3150 3 0 {name=X25 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 3920 3270 3 0 {name=X26 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 3740 3270 3 0 {name=X27 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 3740 3150 3 0 {name=X28 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 3560 3150 3 0 {name=X29 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 3560 3270 3 0 {name=X30 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 3380 3270 3 0 {name=X31 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder.sym} 3380 3150 3 0 {name=X32 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {devices/iopin.sym} 3080 3630 1 0 {name=p1 lab=GND}
C {devices/iopin.sym} 3030 -960 3 0 {name=p6 lab=VDD}
C {inv/inv_sparse_decoder2.sym} 4460 3280 0 0 {name=X3 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder2.sym} 4460 2860 0 0 {name=X5 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder2.sym} 4460 2440 0 0 {name=X7 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder2.sym} 4460 2020 0 0 {name=X9 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder2.sym} 4460 1600 0 0 {name=X11 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder2.sym} 4460 1180 0 0 {name=X13 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder2.sym} 4460 760 0 0 {name=X15 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder2.sym} 4460 340 0 0 {name=X17 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {inv/inv_sparse_decoder2.sym} 4460 -80 0 0 {name=X19 Wpmos=0.42 Lpmos=0.15 Wnmos=0.42 Lnmos=0.15}
C {devices/opin.sym} 4440 3210 0 0 {name=p7 lab=sel61}
C {devices/opin.sym} 4440 3000 0 0 {name=p8 lab=sel60}
