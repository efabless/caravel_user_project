v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/vsource.sym} 2560 8700 0 1 {name=V1 value="DC 0.6 PWL(0 1.2 5 1.2 5.1 1.2 7 1.2 7.1 0 10 0)"}
C {devices/gnd.sym} 2560 8730 0 1 {name=l2 lab=GND}
C {devices/lab_pin.sym} 2560 8670 0 1 {name=l3 sig_type=std_logic lab=A0}
C {devices/vsource.sym} 2985 8695 0 0 {name=V2 value=1.2}
C {devices/gnd.sym} 2985 8725 0 0 {name=l13 lab=GND}
C {devices/vdd.sym} 2985 8665 0 0 {name=l15 lab=VDD}
C {devices/vsource.sym} 2560 8820 0 1 {name=V3 value="DC 0.6 PWL(0 0 5 0 5.1 1.2 7 1.2 7.1 0 10 0)"}
C {devices/gnd.sym} 2560 8850 0 1 {name=l1 lab=GND}
C {devices/lab_pin.sym} 2560 8790 0 0 {name=l4 sig_type=std_logic lab=A1}
C {devices/vsource.sym} 2555 8950 0 1 {name=V4 value="DC 0.6 PWL(0 0 5 0 5.1 1.2 7 1.2 7.1 0 10 0)"}
C {devices/gnd.sym} 2555 8980 0 1 {name=l5 lab=GND}
C {devices/lab_pin.sym} 2555 8920 0 0 {name=l6 sig_type=std_logic lab=A2}
C {devices/lab_pin.sym} 3010 8780 0 0 {name=l7 sig_type=std_logic lab=A0}
C {devices/lab_pin.sym} 3010 8800 0 0 {name=l8 sig_type=std_logic lab=A1}
C {devices/lab_pin.sym} 3010 8820 0 0 {name=l9 sig_type=std_logic lab=A2}
C {devices/lab_pin.sym} 3010 8840 0 0 {name=l10 sig_type=std_logic lab=A3}
C {devices/lab_pin.sym} 3010 8860 0 0 {name=l11 sig_type=std_logic lab=A4}
C {devices/lab_pin.sym} 3010 8880 0 0 {name=l12 sig_type=std_logic lab=A5}
C {devices/lab_pin.sym} 3010 8900 0 0 {name=l14 sig_type=std_logic lab=A6}
C {devices/lab_pin.sym} 3010 8920 0 0 {name=l16 sig_type=std_logic lab=A7}
C {devices/lab_pin.sym} 3010 8940 0 0 {name=l17 sig_type=std_logic lab=A8}
C {devices/lab_pin.sym} 3010 8960 0 0 {name=l18 sig_type=std_logic lab=A9}
C {devices/lab_pin.sym} 3010 8980 0 0 {name=l19 sig_type=std_logic lab=A10}
C {devices/vsource.sym} 2635 8760 0 1 {name=V5 value="DC 0.6 PWL(0 0 5 0 5.1 1.2 7 1.2 7.1 0 10 0)"}
C {devices/gnd.sym} 2635 8790 0 1 {name=l20 lab=GND}
C {devices/lab_pin.sym} 2635 8730 0 1 {name=l21 sig_type=std_logic lab=A3}
C {devices/vsource.sym} 2635 8880 0 1 {name=V6 value="DC 0.6 PWL(0 0 5 0 5.1 1.2 7 1.2 7.1 0 10 0)"}
C {devices/gnd.sym} 2635 8910 0 1 {name=l22 lab=GND}
C {devices/lab_pin.sym} 2635 8850 0 0 {name=l23 sig_type=std_logic lab=A4}
C {devices/vsource.sym} 2630 9010 0 1 {name=V7 value="DC 0.6 PWL(0 0 5 0 5.1 1.2 7 1.2 7.1 0 10 0)"}
C {devices/gnd.sym} 2630 9040 0 1 {name=l24 lab=GND}
C {devices/lab_pin.sym} 2630 8980 0 0 {name=l25 sig_type=std_logic lab=A5}
C {devices/vsource.sym} 2825 8795 0 1 {name=V8 value="DC 0.6 PWL(0 0 5 0 5.1 1.2 7 1.2 7.1 0 10 0)"}
C {devices/gnd.sym} 2825 8825 0 1 {name=l26 lab=GND}
C {devices/lab_pin.sym} 2825 8765 0 1 {name=l27 sig_type=std_logic lab=A6}
C {devices/vsource.sym} 2825 8915 0 1 {name=V9 value="DC 0.6 PWL(0 0 5 0 5.1 1.2 7 1.2 7.1 0 10 0)"}
C {devices/gnd.sym} 2825 8945 0 1 {name=l28 lab=GND}
C {devices/lab_pin.sym} 2825 8885 0 0 {name=l29 sig_type=std_logic lab=A7}
C {devices/vsource.sym} 2820 9045 0 1 {name=V10 value="DC 0.6 PWL(0 0 5 0 5.1 1.2 7 1.2 7.1 0 10 0)"}
C {devices/gnd.sym} 2820 9075 0 1 {name=l30 lab=GND}
C {devices/lab_pin.sym} 2820 9015 0 0 {name=l31 sig_type=std_logic lab=A8}
C {devices/vsource.sym} 2885 8800 0 1 {name=V11 value="DC 0.6 PWL(0 0 5 0 5.1 1.2 7 1.2 7.1 0 10 0)"}
C {devices/gnd.sym} 2885 8830 0 1 {name=l32 lab=GND}
C {devices/lab_pin.sym} 2885 8770 0 1 {name=l33 sig_type=std_logic lab=A9}
C {devices/vsource.sym} 2885 8920 0 1 {name=V12 value="DC 0.6 PWL(0 0 5 0 5.1 1.2 7 1.2 7.1 0 10 0)"}
C {devices/gnd.sym} 2885 8950 0 1 {name=l34 lab=GND}
C {devices/lab_pin.sym} 2885 8890 0 0 {name=l35 sig_type=std_logic lab=A10}
C {devices/netlist.sym} 3315 8560 0 0 {name=SPICE value="
.lib /home/sky/sky130A/libs.tech/ngspice/sky130.lib.spice tt
*.include /home/sky/sky130A/libs.ref/sky130_fd_sc_lp/spice/sky130_fd_sc_lp.spice
.options abstol=1e-14 reltol=1e-4
.tran 0.1 10
.save all
"}
C {devices/lab_pin.sym} 3370 8880 2 0 {name=l36 sig_type=std_logic lab=out}
C {sparse_nor/sparse_nor.sym} 3910 2660 0 0 {name=X1}
